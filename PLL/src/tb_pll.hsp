* Disclaimer:
* THIS FILE IS PROVIDED AS IS AND WITH:
* (A) NO WARRANTY OF ANY KIND, express, implied or statutory, including any implied warranties of merchantability, fitness for a particular purpose and noninfringement, which  Infineon disclaims to the maximum extent permitted by applicable law; and
* (B) NO INDEMNIFICATION FOR INFRINGEMENT OF INTELLECTUAL PROPERTY RIGHTS.
* (C) LIMITATION OF LIABILITY: IN NO EVENT SHALL INFINEON BE LIABLE FOR ANY DIRECT, INDIRECT, SPECIAL, INCIDENTAL, OR CONSEQUENTIAL DAMAGES (INCLUDING LOST PROFITS OR SAVINGS) WHATSOEVER, WHETHER BASED ON CONTRACT, TORT OR ANY OTHER LEGAL THEORY, EVEN IF ADVISED OF THE POSSIBILITY OF SUCH DAMAGES.
* © 2020 Infineon Technologies AG. All rights reserved.

* Note:
* The CMOS transistor models used, were freely available models downloaded from: http://ptm.asu.edu.
* The bipolar transistor models are from: The Development of Bipolar Log-Domain Filters in a Standard CMOS Process, G. D. Duerden, G. W. Roberts, M. J. Deen, 2001

* Release:
* 	version 1.0

.SUBCKT SUPPLIES INH_BULKN INH_BULKPANALOG INH_BULKPCORE INH_HSUPANALOG INH_HSUPCORE INH_LSUP
  V0 NET7 INH_LSUP DC='vsup2v5' PULSE( '0' 'vsup2v5' 'td_ps' 'tr_ps' '1m' '9' '10' )
  V1 NET8 INH_LSUP DC='vsup1v5' PULSE( '0' 'vsup1v5' 'td_ps' 'tr_ps' '1m' '9' '10' )
  R5 0 INH_LSUP R='1m'
  R4 INH_HSUPCORE NET8 R='rhsupcore'
  R3 INH_HSUPANALOG NET7 R='rhsupanalog'
  R2 INH_HSUPANALOG INH_BULKPANALOG R='rbulkpanalog'
  R1 INH_HSUPCORE INH_BULKPCORE R='rbulkpcore'
  R0 INH_LSUP INH_BULKN R='1m'
.ENDS

.SUBCKT SUB_DIODE MINUS PLUS INH_BULK_N
  Q1 MINUS MINUS PLUS INH_BULK_N LATPNP
.ENDS

.SUBCKT AND2 A B Z INH_BULK_N INH_BULK_P INH_HSUP INH_LSUP
  MPTRANS25 Z NET39 INH_HSUP INH_BULK_P PREG W='860.0n' L='120.0n' M='1'
  MPTRANS24 NET39 A INH_HSUP INH_BULK_P PREG W='700n' L='120.0n' M='1'
  MPTRANS23 NET39 B INH_HSUP INH_BULK_P PREG W='700n' L='120.0n' M='1'
  MNTRANS22 Z NET39 INH_LSUP INH_BULK_N NREG W='600n' L='120.0n' M='1'
  MNTRANS21 NET39 A NET32 INH_BULK_N NREG W='700n' L='120.0n' M='1'
  MNTRANS20 NET32 B INH_LSUP INH_BULK_N NREG W='700n' L='120.0n' M='1'
  XINSTANCE1 INH_HSUP INH_LSUP INH_BULK_N SUB_DIODE
.ENDS

.SUBCKT INV2 A Z INH_BULK_N INH_BULK_P INH_HSUP INH_LSUP
  MPTRANS10 Z A INH_HSUP INH_BULK_P PREG W='1.62u' L='120.0n' M='1'
  MNTRANS11 Z A INH_LSUP INH_BULK_N NREG W='1.12u' L='120.0n' M='1'
  XINSTANCE1 INH_HSUP INH_LSUP INH_BULK_N SUB_DIODE
.ENDS

.SUBCKT DFF CLK D Q QB INH_BULKCORE INH_BULKN INH_HSUPCORE INH_LSUP
  M121 NET52 B INH_LSUP INH_BULKN NREG W='130n' L='130n' M='1'
  M132 NET47 CLK INH_LSUP INH_BULKN NREG W='130n' L='130n' M='1'
  M130 A B NET47 INH_BULKN NREG W='130n' L='130n' M='1'
  M128 NET49 CLK INH_LSUP INH_BULKN NREG W='130n' L='130n' M='1'
  M126 B C NET49 INH_BULKN NREG W='130n' L='130n' M='1'
  M124 C Q NET52 INH_BULKN NREG W='130n' L='130n' M='1'
  M45 A D INH_LSUP INH_BULKN NREG W='130n' L='130n' M='1'
  M120 NET38 CLK INH_LSUP INH_BULKN NREG W='325n' L='130n' M='1'
  M53 C CLK NET36 INH_BULKN NREG W='260n' L='130n' M='1'
  M52 B A NET38 INH_BULKN NREG W='325n' L='130n' M='1'
  M51 NET36 B INH_LSUP INH_BULKN NREG W='260n' L='130n' M='1'
  M54 Q C INH_LSUP INH_BULKN NREG W='130n' L='130n' M='1'
  M131 A B NET46 INH_BULKCORE PREG W='130n' L='130n' M='1'
  M129 NET46 D INH_HSUPCORE INH_BULKCORE PREG W='130n' L='130n' M='1'
  M127 B C NET44 INH_BULKCORE PREG W='130n' L='130n' M='1'
  M122 C Q NET42 INH_BULKCORE PREG W='130n' L='130n' M='1'
  M125 NET44 A INH_HSUPCORE INH_BULKCORE PREG W='130n' L='130n' M='1'
  M123 NET42 CLK INH_HSUPCORE INH_BULKCORE PREG W='130n' L='130n' M='1'
  M55 Q C INH_HSUPCORE INH_BULKCORE PREG W='390n' L='130n' M='1'
  M43 NET40 D INH_HSUPCORE INH_BULKCORE PREG W='580n' L='130n' M='1'
  M119 A CLK NET40 INH_BULKCORE PREG W='580n' L='130n' M='1'
  M48 B CLK INH_HSUPCORE INH_BULKCORE PREG W='490n' L='130n' M='1'
  M49 C B INH_HSUPCORE INH_BULKCORE PREG W='390n' L='130n' M='1'
  R0 C QB R='1u'
.ENDS

.SUBCKT DIV2_3 CTRL FIN FOUT MOD_IN MOD_OUT INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP
  XI146 FIN NET9 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV2
  XI0 MOD_IN FOUT NET20 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP AND2
  XI160 NET010 NET13 NET18 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP AND2
  XI153 CTRL MOD_OUT NET19 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP AND2
  XI141 NET9 NET19 NET22 NET13 INH_BULKCORE INH_BULKN INH_HSUPCORE INH_LSUP DFF
  XI140 FIN NET20 MOD_OUT NET23 INH_BULKCORE INH_BULKN INH_HSUPCORE INH_LSUP DFF
  XI139 NET9 NET14 FOUT NET010 INH_BULKCORE INH_BULKN INH_HSUPCORE INH_LSUP DFF
  XI138 FIN NET18 NET14 NET24 INH_BULKCORE INH_BULKN INH_HSUPCORE INH_LSUP DFF
.ENDS

.SUBCKT SMTT_BUF DI DO INH_BULKCORE INH_BULKN INH_HSUPCORE INH_LSUP
  M2 DO NET7 NET12 INH_BULKCORE PREG W='860n' L='130n' M='2'
  M90 INH_LSUP DO NET12 INH_BULKCORE PREG W='130n' L='130n' M='1'
  M3 NET12 NET7 INH_HSUPCORE INH_BULKCORE PREG W='860n' L='130n' M='2'
  M81 NET6 DI INH_HSUPCORE INH_BULKCORE PREG W='860n' L='130n'
  M80 NET7 DI NET6 INH_BULKCORE PREG W='860n' L='130n'
  M84 INH_LSUP NET7 NET6 INH_BULKCORE PREG W='130n' L='130n' M='1'
  M91 INH_HSUPCORE DO NET10 INH_BULKN NREG W='130n' L='130n' M='1'
  M85 INH_HSUPCORE NET7 NET4 INH_BULKN NREG W='130n' L='130n' M='1'
  M1 DO NET7 NET10 INH_BULKN NREG W='600n' L='130n' M='2'
  M0 NET10 NET7 INH_LSUP INH_BULKN NREG W='600n' L='130n' M='2'
  M83 NET7 DI NET4 INH_BULKN NREG W='600n' L='130n' M='1'
  M82 NET4 DI INH_LSUP INH_BULKN NREG W='600n' L='130n'
.ENDS

.SUBCKT OR2 A B Z INH_BULK_N INH_BULK_P INH_HSUP INH_LSUP
  MNTRANS27 NET26 A INH_LSUP INH_BULK_N NREG W='900n' L='120.0n' M='1'
  MNTRANS26 NET26 B INH_LSUP INH_BULK_N NREG W='900n' L='120.0n' M='1'
  MNTRANS25 Z NET26 INH_LSUP INH_BULK_N NREG W='600n' L='120.0n' M='1'
  MPTRANS24 NET26 A NET41 INH_BULK_P PREG W='1.28u' L='120.0n' M='1'
  MPTRANS23 NET41 B INH_HSUP INH_BULK_P PREG W='1.28u' L='120.0n' M='1'
  MPTRANS22 Z NET26 INH_HSUP INH_BULK_P PREG W='860.0n' L='120.0n' M='1'
  XINSTANCE1 INH_HSUP INH_LSUP INH_BULK_N SUB_DIODE
.ENDS

.SUBCKT INV1 A Z INH_BULK_N INH_BULK_P INH_HSUP INH_LSUP
  MPTRANS10 Z A INH_HSUP INH_BULK_P PREG W='860.0n' L='120.0n' M='1'
  MNTRANS11 Z A INH_LSUP INH_BULK_N NREG W='600n' L='120.0n' M='1'
  XINSTANCE1 INH_HSUP INH_LSUP INH_BULK_N SUB_DIODE
.ENDS

.SUBCKT FB_DIVIDER DISABLE FIN FOUT P0 P1 P2 P3 P4 INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP
  XI18 NET038 NET06 FOUT INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP AND2
  XI17 NET038 NET037 NET039 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP AND2
  XI164 P0 NET039 NET015 NET06 NET31 INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP DIV2_3
  XI163 P1 NET015 NET25 NET010 NET06 INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP DIV2_3
  XI162 P2 NET25 NET021 NET014 NET26 INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP DIV2_3
  XI170 P3 NET021 NET22 INH_HSUPCORE NET24 INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP DIV2_3
  XI150 FIN NET037 INH_BULKCORE INH_BULKN INH_HSUPCORE INH_LSUP SMTT_BUF
  XI22 P3 P4 NET030 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP OR2
  XI171 NET011 NET26 NET010 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP OR2
  XI24 NET043 NET24 NET014 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP OR2
  XI19 DISABLE NET038 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI23 P4 NET043 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV2
  XI21 NET030 NET011 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV2
.ENDS

.SUBCKT INV3 A Z INH_BULK_N INH_BULK_P INH_HSUP INH_LSUP
  MPTRANS10 Z A INH_HSUP INH_BULK_P PREG W='2.44u' L='120.0n' M='1'
  MNTRANS11 Z A INH_LSUP INH_BULK_N NREG W='1.7u' L='120.0n' M='1'
  XINSTANCE1 INH_HSUP INH_LSUP INH_BULK_N SUB_DIODE
.ENDS

.SUBCKT DFF_RST CLK D Q QB RST INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP
  M3 Q RST INH_LSUP INH_BULKN NREG W='130n' L='130n' M='2'
  M2 B RST INH_LSUP INH_BULKN NREG W='130n' L='130n' M='2'
  M121 NET52 B INH_LSUP INH_BULKN NREG W='130n' L='130n' M='1'
  M132 NET47 CLK INH_LSUP INH_BULKN NREG W='130n' L='130n' M='1'
  M130 A B NET47 INH_BULKN NREG W='130n' L='130n' M='1'
  M128 NET49 CLK INH_LSUP INH_BULKN NREG W='130n' L='130n' M='1'
  M126 B C NET49 INH_BULKN NREG W='130n' L='130n' M='1'
  M124 C Q NET52 INH_BULKN NREG W='130n' L='130n' M='1'
  M45 A D INH_LSUP INH_BULKN NREG W='130n' L='130n' M='4'
  M120 NET38 CLK INH_LSUP INH_BULKN NREG W='325n' L='130n' M='4'
  M53 C CLK NET36 INH_BULKN NREG W='260n' L='130n' M='4'
  M52 B A NET38 INH_BULKN NREG W='325n' L='130n' M='4'
  M51 NET36 B INH_LSUP INH_BULKN NREG W='260n' L='130n' M='4'
  M54 Q C INH_LSUP INH_BULKN NREG W='130n' L='130n' M='1'
  M1 A NET016 INH_HSUPCORE INH_BULKCORE PREG W='130n' L='130n' M='2'
  M0 C NET016 INH_HSUPCORE INH_BULKCORE PREG W='130n' L='130n' M='2'
  M131 A B NET46 INH_BULKCORE PREG W='130n' L='130n' M='1'
  M129 NET46 D INH_HSUPCORE INH_BULKCORE PREG W='130n' L='130n' M='1'
  M127 B C NET44 INH_BULKCORE PREG W='130n' L='130n' M='1'
  M122 C Q NET42 INH_BULKCORE PREG W='130n' L='130n' M='1'
  M125 NET44 A INH_HSUPCORE INH_BULKCORE PREG W='130n' L='130n' M='1'
  M123 NET42 CLK INH_HSUPCORE INH_BULKCORE PREG W='130n' L='130n' M='1'
  M55 Q C INH_HSUPCORE INH_BULKCORE PREG W='390n' L='130n' M='1'
  M43 NET40 D INH_HSUPCORE INH_BULKCORE PREG W='580n' L='130n' M='4'
  M119 A CLK NET40 INH_BULKCORE PREG W='580n' L='130n' M='4'
  M48 B CLK INH_HSUPCORE INH_BULKCORE PREG W='490n' L='130n' M='4'
  M49 C B INH_HSUPCORE INH_BULKCORE PREG W='390n' L='130n' M='4'
  R0 C QB R='1u'
  XI0 RST NET016 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV2
.ENDS

.SUBCKT INV4 A Z INH_BULK_N INH_BULK_P INH_HSUP INH_LSUP
  MPTRANS10 Z A INH_HSUP INH_BULK_P PREG W='3.24u' L='120.0n' M='1'
  MNTRANS11 Z A INH_LSUP INH_BULK_N NREG W='2.24u' L='120.0n' M='1'
  XINSTANCE1 INH_HSUP INH_LSUP INH_BULK_N SUB_DIODE
.ENDS

.SUBCKT PFD CLK DISABLE DN REF UP INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP
  XI25 NET013 NET014 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV3
  XI19 NET018 NET024 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV3
  XI0 CLK INH_HSUPCORE NET023 NET14 RST INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP DFF_RST
  XI138 REF INH_HSUPCORE NET022 NET016 RST INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP DFF_RST
  XI28 NET027 NET011 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI27 NET021 NET012 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI34 DISABLE NET020 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI30 NET14 NET08 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI29 NET016 NET09 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI35 NET08 NET09 NET028 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP AND2
  XI31 NET09 NET08 NET034 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP AND2
  XI33 NET020 NET023 NET027 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP AND2
  XI32 NET020 NET022 NET021 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP AND2
  XI24 NET011 NET013 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV2
  XI16 NET012 NET018 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV2
  XI26 NET014 DN INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV4
  XI21 NET024 UP INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV4
  R1 RST NET034 R='50'
  R0 RST NET028 R='50'
.ENDS

.SUBCKT CH_PUMP BIAS CPOUT DISABLE DN LOCK UP INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP
  M20 NET030 NET044 INH_LSUP INH_BULKN NREG W='130n' L='130n' M='10'
  M18 CPOUT DISABLE INH_LSUP INH_BULKN NREG W='130n' L='130n' M='2'
  M16 NET6 DISABLE INH_LSUP INH_BULKN NREG W='130n' L='130n' M='2'
  M21 NET041 NET044 NET6 INH_BULKN NREG W='130n' L='130n' M='2'
  M11 NET033 NET027 NET013 INH_BULKN NREG W='130n' L='130n' M='1'
  M9 NET016 NET6 INH_LSUP INH_BULKN NREG W='130n' L='260n' M='1'
  M7 INH_HSUPCORE CPOUT NET016 INH_BULKN NREG W='130n' L='130n' M='4'
  M6 CPOUT NET04 NET06 INH_BULKN NREG W='130n' L='130n' M='1'
  M5 NET013 NET011 NET06 INH_BULKN NREG W='130n' L='130n' M='1'
  M0 NET06 NET6 INH_LSUP INH_BULKN NREG W='130n' L='260n' M='2'
  M12 NET6 NET6 INH_LSUP INH_BULKN NREG W='130n' L='260n' M='2'
  M26 NET055 NET042 INH_HSUPCORE INH_BULKCORE PREG W='390n' L='260n' M='2'
  M25 NET055 NET042 INH_HSUPCORE INH_BULKCORE PREG W='390n' L='260n' M='2'
  M24 NET055 NET012 NET042 INH_BULKCORE PREG W='390n' L='260n' M='2'
  M23 NET055 NET012 NET042 INH_BULKCORE PREG W='390n' L='260n' M='2'
  M22 NET055 NET042 INH_HSUPCORE INH_BULKCORE PREG W='390n' L='260n' M='2'
  M19 NET033 DISABLE INH_HSUPCORE INH_BULKCORE PREG W='130n' L='130n' M='10'
  M17 NET042 NET044 INH_HSUPCORE INH_BULKCORE PREG W='130n' L='130n' M='2'
  M13 NET030 NET016 NET013 INH_BULKCORE PREG W='390n' L='130n' M='1'
  M10 NET027 NET042 INH_HSUPCORE INH_BULKCORE PREG W='390n' L='260n' M='1'
  M8 INH_LSUP CPOUT NET027 INH_BULKCORE PREG W='390n' L='130n' M='4'
  M4 CPOUT NET018 NET07 INH_BULKCORE PREG W='390n' L='130n' M='1'
  M3 NET013 NET05 NET07 INH_BULKCORE PREG W='390n' L='130n' M='1'
  M2 NET07 NET042 INH_HSUPCORE INH_BULKCORE PREG W='390n' L='260n' M='2'
  M1 NET041 NET042 INH_HSUPCORE INH_BULKCORE PREG W='390n' L='260n' M='2'
  M41 NET042 NET042 INH_HSUPCORE INH_BULKCORE PREG W='390n' L='260n' M='2'
  M14 BIAS DISABLE NET042 INH_BULKCORE PREG W='130n' L='130n' M='2'
  XI22 LOCK NET012 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI17 DISABLE NET044 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI14 DN NET022 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI13 UP NET023 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI6 NET04 NET011 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI55 NET05 NET018 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI16 NET022 NET04 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV2
  XI15 NET023 NET05 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV2
  R0 INH_HSUPCORE LOCK R='250K'
.ENDS

.SUBCKT OSC DISABLE OSCCTRL OSCOUT OSCOUTB INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP NET0
  M137 OUTP DISABLE NET0 INH_BULKN NREG W='130n' L='130n' M='1'
  M20 OUTN RSTN NET0 INH_BULKN NREG W='520n' L='130n' M='1'
  M40 OUTP RSTP NET0 INH_BULKN NREG W='520n' L='130n' M='1'
  M12 NET018 OUTP NET0 INH_BULKN NREG W='130n' L='130n' M='1'
  M38 NET066 OUTN NET0 INH_BULKN NREG W='130n' L='130n' M='1'
  M136 OUTN NET026 INH_HSUPCORE INH_BULKCORE PREG W='130n' L='130n' M='1'
  M41 CURIN OSCCTRL INH_HSUPCORE INH_BULKCORE PREG W='520n' L='260n' M='3'
  M42 OSCCTRL OSCCTRL INH_HSUPCORE INH_BULKCORE PREG W='520n' L='260n' M='8'
  M133 OSCCTRL NET026 INH_HSUPCORE INH_BULKCORE PREG W='130n' L='130n' M='1'
  M9 NET018 OUTP CURIN INH_BULKCORE PREG W='400n' L='130n' M='1'
  M39 NET066 OUTN CURIN INH_BULKCORE PREG W='400n' L='130n' M='1'
  XI126 NET018 RSTN INH_BULKCORE INH_BULKN INH_HSUPCORE INH_LSUP SMTT_BUF
  XI127 NET066 RSTP INH_BULKCORE INH_BULKN INH_HSUPCORE INH_LSUP SMTT_BUF
  XI55 OUTP OUTN NET0 INH_BULKPCORE INH_HSUPCORE NET0 INV1
  XI194 DISABLE NET026 NET0 INH_BULKPCORE INH_HSUPCORE NET0 INV1
  XI189 OUTN OUTP NET0 INH_BULKPCORE INH_HSUPCORE NET0 INV1
  XI190 OUTP NET016 NET0 INH_BULKPCORE INH_HSUPCORE NET0 INV1
  XI191 OUTN NET035 NET0 INH_BULKPCORE INH_HSUPCORE NET0 INV1
  XI198 NET026 NET016 OSCOUT NET0 INH_BULKPCORE INH_HSUPCORE NET0 AND2
  XI193 NET026 NET035 OSCOUTB NET0 INH_BULKPCORE INH_HSUPCORE NET0 AND2
.ENDS

.SUBCKT DIVIDER DISABLE FIN FOUT P0 P1 P2 P3 P4 P5 P6 INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP
  XI18 NET038 NET06 FOUT INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP AND2
  XI20 NET038 NET037 NET041 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP AND2
  XI164 P0 NET041 NET015 NET06 NET31 INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP DIV2_3
  XI163 P1 NET015 NET25 NET036 NET06 INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP DIV2_3
  XI162 P2 NET25 NET021 NET032 NET26 INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP DIV2_3
  XI170 P3 NET021 NET22 NET11 NET24 INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP DIV2_3
  XI169 P4 NET22 NET20 NET14 NET21 INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP DIV2_3
  XI168 P5 NET20 NET6 INH_HSUPCORE NET19 INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP DIV2_3
  XI150 FIN NET037 INH_BULKCORE INH_BULKN INH_HSUPCORE INH_LSUP SMTT_BUF
  XI9 P3 NET010 NET012 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP OR2
  XI8 NET013 NET26 NET036 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP OR2
  XI1 NET13 NET21 NET11 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP OR2
  XI2 NET15 NET19 NET14 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP OR2
  XI171 P5 P6 NET12 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP OR2
  XI6 P4 NET12 NET010 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP OR2
  XI4 NET011 NET24 NET032 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP OR2
  XI19 DISABLE NET038 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI7 NET012 NET013 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV2
  XI0 NET12 NET13 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV2
  XI3 P6 NET15 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV2
  XI5 NET010 NET011 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV2
.ENDS

.SUBCKT EXOR A B Z INH_BULK_N INH_BULK_P INH_HSUP INH_LSUP
  MPTRANS26 NET5 NET125 INH_HSUP INH_BULK_P PREG W='1.32u' L='120.0n' M='1'
  MPTRANS27 Z B NET5 INH_BULK_P PREG W='1.32u' L='120.0n' M='1'
  MPTRANS3 NET125 A INH_HSUP INH_BULK_P PREG W='1.28u' L='120.0n' M='1'
  MPTRANS11 NET26 B INH_HSUP INH_BULK_P PREG W='1.28u' L='120.0n' M='1'
  MPTRANS18 Z A NET14 INH_BULK_P PREG W='1.32u' L='120.0n' M='1'
  MPTRANS22 NET14 NET26 INH_HSUP INH_BULK_P PREG W='1.32u' L='120.0n' M='1'
  MNTRANS29 Z NET26 NET22 INH_BULK_N NREG W='920.0n' L='120.0n' M='1'
  MNTRANS28 NET22 NET125 INH_LSUP INH_BULK_N NREG W='920.0n' L='120.0n' M='1'
  MNTRANS4 NET125 A INH_LSUP INH_BULK_N NREG W='900n' L='120.0n' M='1'
  MNTRANS12 NET26 B INH_LSUP INH_BULK_N NREG W='900n' L='120.0n' M='1'
  MNTRANS19 Z A NET28 INH_BULK_N NREG W='920.0n' L='120.0n' M='1'
  MNTRANS23 NET28 B INH_LSUP INH_BULK_N NREG W='920.0n' L='120.0n' M='1'
  XINSTANCE1 INH_HSUP INH_LSUP INH_BULK_N SUB_DIODE
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: pll
** Cell name: lock_det
** View name: schematic
** Inherited view list: spectre systemVerilog verilogams veriloga module behavioral functional netlist schematic symbol
**
.SUBCKT LOCK_DET DISABLE DIV DN LOCK REF UP INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP
  XI83 REFBUF NET031 NET032 NET070 RESET INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP DFF_RST
  XI82 REFBUF NET030 NET031 NET071 RESET INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP DFF_RST
  XI81 REFBUF INH_HSUPCORE NET030 NET060 RESET INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP DFF_RST
  XI85 REFBUF NET033 NET012 NET052 RESET INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP DFF_RST
  XI84 REFBUF NET032 NET033 NET065 RESET INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP DFF_RST
  XI121 NET0120 RESET INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV2
  XI6 NET011 NET043 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV2
  XI3 NET09 NET025 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV2
  XI0 NET5 NET026 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV2
  XI16 NET6 NET046 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV2
  XI123 NET0119 NET0123 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI122 NET020 NET0119 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI120 NET0117 NET0120 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI119 NET0118 NET035 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI118 NET029 NET0118 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI117 DISABLE NET049 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI115 NET0101 NET0107 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI114 NET0107 NET029 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI104 NET078 NET093 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI103 NET093 NET0101 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI102 NET092 NET078 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI101 NET042 NET092 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI99 NET045 NET084 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI98 NET035 NET045 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI97 NET099 NET091 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI96 NET084 NET099 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI94 NET079 NET080 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI93 NET080 NET076 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI92 NET040 NET079 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI91 NET012 NET040 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI89 NET087 NET036 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI88 NET076 NET087 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI87 NET088 NET089 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI113 NET0104 NET095 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI112 NET095 NET0102 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI111 NET094 NET0104 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI69 NET023 NET055 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI67 NET018 NET023 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI86 NET036 NET088 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI66 NET024 NET020 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI110 NET081 NET094 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI7 DIV NET011 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI4 REF NET09 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI108 NET0105 NET083 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI107 NET0102 NET0105 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI106 NET097 NET098 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI105 NET083 NET097 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI65 NET038 NET024 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI1 DN NET5 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI15 UP NET6 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV1
  XI17 NET082 NET0117 INH_BULKCORE INH_BULKN INH_HSUPCORE INH_LSUP SMTT_BUF
  XI100 NET042 NET091 NET082 INH_BULKN INH_BULKCORE INH_HSUPCORE INH_LSUP AND2
  XI90 NET012 NET089 NET050 INH_BULKN INH_BULKCORE INH_HSUPCORE INH_LSUP AND2
  XI109 NET081 NET098 INPHASE INH_BULKN INH_BULKCORE INH_HSUPCORE INH_LSUP AND2
  XI116 NET049 NET050 LOCK INH_BULKN INH_BULKCORE INH_HSUPCORE INH_LSUP AND2
  XI30 NET022 NET041 CYCLESLIP INH_BULKN INH_BULKCORE INH_HSUPCORE INH_LSUP OR2
  XI76 CYCLESLIP INPHASE NET042 INH_BULKN INH_BULKCORE INH_HSUPCORE INH_LSUP OR2
  XI29 DIVBUF DNBUF NET041 NET051 INH_BULKCORE INH_BULKN INH_HSUPCORE INH_LSUP DFF
  XI138 REFBUF UPBUF NET022 NET019 INH_BULKCORE INH_BULKN INH_HSUPCORE INH_LSUP DFF
  XI51 NET0123 NET055 NET081 INH_BULKN INH_BULKCORE INH_HSUPCORE INH_LSUP EXOR
  XI58 NET026 NET048 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV3
  XI57 NET046 NET047 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV3
  XI60 NET043 NET054 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV3
  XI59 NET025 NET053 INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV3
  XI64 NET048 DNBUF INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV4
  XI63 NET047 UPBUF INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV4
  XI62 NET054 DIVBUF INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV4
  XI61 NET053 REFBUF INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP INV4
  XI14 UPBUF DISABLE NET018 DNBUF NET038 INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP PFD
.ENDS

.SUBCKT PLL ADC_CLK ADCDIV0 ADCDIV1 ADCDIV2 ADCDIV3 ADCDIV4 ADCDIV5 ADCDIV6 DISABLE DIVTEST FREF IBIAS5U LDO_CLK LDODIV0 LDODIV1 LDODIV2 LDODIV3 LDODIV4 LDODIV5 LDODIV6 LOCK SYS_CLK SYSDIV0 SYSDIV1 SYSDIV2 SYSDIV3 SYSDIV4 INH_BULK_P INH_BULKCORE INH_BULKN
+ INH_BULKPCORE INH_HSUPCORE NET0 INH_LSUP
  XI10 DISABLE NET082 DIVOUT SYSDIV0 SYSDIV1 SYSDIV2 SYSDIV3 SYSDIV4 INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE NET0 FB_DIVIDER
  XI12 OSCOUT NET06 INH_BULKCORE INH_BULKN INH_HSUPCORE NET0 SMTT_BUF
  XI67 OSCOUTB NET057 INH_BULKCORE INH_BULKN INH_HSUPCORE NET0 SMTT_BUF
  XI17 FREF NET020 INH_BULKCORE INH_BULKN INH_HSUPCORE NET0 SMTT_BUF
  XI19 DIVOUT NET021 INH_BULKCORE INH_BULKN INH_HSUPCORE NET0 SMTT_BUF
  XI14 DIV DISABLE DN REF UP INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE NET0 PFD
  M4 OSCIN NET038 NET059 INH_BULKN NREG W='130n' L='130n' M='16'
  M2 NET038 NET056 FILTOUT INH_BULKN NREG W='130n' L='130n' M='1'
  M1 NET038 DISABLE NET0 INH_BULKN NREG W='130n' L='130n' M='1'
  XI32 IBIAS5U FILTOUT DISABLE DN LOCK UP INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE INH_LSUP CH_PUMP
  R6 NET059 NET0 R='4K'
  R0 FILTOUT NET014 R='20K'
  XI0 DISABLE OSCIN OSCOUT OSCOUTB INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE NET0 INH_LSUP OSC
  M3 FILTOUT DISABLE NET038 INH_BULK_P PREG W='130n' L='130n' M='1'
  XI70 NET050 NET049 NET083 NET049 INH_BULKCORE INH_BULKN INH_HSUPCORE NET0 DFF
  XI57 DISABLE NET084 NET069 LDODIV0 LDODIV1 LDODIV2 LDODIV3 LDODIV4 LDODIV5 LDODIV6 INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE NET0 DIVIDER
  XI51 DISABLE NET026 NET086 ADCDIV0 ADCDIV1 ADCDIV2 ADCDIV3 ADCDIV4 ADCDIV5 ADCDIV6 INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE NET0 DIVIDER
  C0 FILTOUT NET0 C='3p'
  C2 NET014 NET0 C='50p'
  XI42 DISABLE DIV DN LOCK REF UP INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE NET0 LOCK_DET
  XI72 NET058 NET082 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV4
  XI69 NET077 NET050 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV4
  XI61 NET075 SYS_CLK INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV4
  XI59 NET028 LDO_CLK INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV4
  XI54 NET070 ADC_CLK INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV4
  XI53 NET090 NET026 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV4
  XI47 NET033 DIV INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV4
  XI46 NET032 REF INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV4
  XI79 NET090 NET098 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV2
  XI78 DIVTEST NET066 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV2
  XI71 NET083 NET058 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV2
  XI66 DISABLE NET056 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV2
  XI62 NET098 NET075 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV2
  XI60 NET029 NET028 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV2
  XI56 NET037 NET070 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV2
  XI52 NET06 NET090 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV2
  XI45 NET021 NET033 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV2
  XI55 NET020 NET032 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV2
  XI68 NET057 NET077 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP INV2
  XI73 NET086 NET012 NET037 NET012 DISABLE INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE NET0 DFF_RST
  XI74 NET069 NET025 NET029 NET025 DISABLE INH_BULKCORE INH_BULKN INH_BULKPCORE INH_HSUPCORE NET0 DFF_RST
  XI77 NET066 NET070 NET081 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP AND2
  XI76 DIVTEST NET090 NET089 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP AND2
  XI75 NET081 NET089 NET084 INH_LSUP INH_BULKPCORE INH_HSUPCORE INH_LSUP OR2
.ENDS

XI2 VSSB! VDDBA! VDDBC! VDDA! VDDC! VSS! SUPPLIES
XDUT ADCCLK NET017 NET018 NET019 NET020 NET021 NET022 NET04 NET033 NET038 NET3 NET4 LDOCLK NET026 NET03 NET028 NET029 NET030 NET031 NET032 LOCK SYSCLK NET012 NET013 NET014 NET015 NET09 VDD! VDDBC! VSSB! VDDBC! VDDC! VSS! VSS! PLL
XSTIM ADCCLK LDOCLK LOCK SYSCLK NET4 NET017 NET018 NET019 NET020 NET021 NET022 NET04 NET033 NET3 NET026 NET03 NET028 NET029 NET030 NET031 NET032 NET012 NET013 NET014 NET015 NET09 0 NET038 FAIL TESTNR pll_stim ibias_real='5e-06' vhigh='1.5' trf='1e-09'
+ ref_freq='7.373e+06' freq_tolerance='0.02' period_averaging='5'
