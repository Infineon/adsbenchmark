** Disclaimer:
** THIS FILE IS PROVIDED AS IS AND WITH:
** (A) NO WARRANTY OF ANY KIND, express, implied or statutory, including any implied warranties of merchantability, fitness for a particular purpose and noninfringement, which  Infineon disclaims to the maximum extent permitted by applicable law; and
** (B) NO INDEMNIFICATION FOR INFRINGEMENT OF INTELLECTUAL PROPERTY RIGHTS.
** (C) LIMITATION OF LIABILITY: IN NO EVENT SHALL INFINEON BE LIABLE FOR ANY DIRECT, INDIRECT, SPECIAL, INCIDENTAL, OR CONSEQUENTIAL DAMAGES (INCLUDING LOST PROFITS OR SAVINGS) WHATSOEVER, WHETHER BASED ON CONTRACT, TORT OR ANY OTHER LEGAL THEORY, EVEN IF ADVISED OF THE POSSIBILITY OF SUCH DAMAGES.
** © 2020 Infineon Technologies AG. All rights reserved.

** Note:
** The CMOS transistor models used, were freely available models downloaded from: http://ptm.asu.edu.
** The bipolar transistor models are from: The Development of Bipolar Log-Domain Filters in a Standard CMOS Process, G. D. Duerden, G. W. Roberts, M. J. Deen, 2001

** Release:
** version 1.0

.GLOBAL VSS! VDDc! VDDba! VSSb! VDDa! VDDbc!

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: va_relay
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT va_relay A Z en_i inh_lSup
  GW0 A Z VCR PWL(1) en_i inh_lSup ('700m' '1.0G' '800.0m' '100.0m')
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: lane_output
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT lane_output bin_o diff_o S0_i cn_i cp_i bin_no inh_lSup
  E0 diff_o inh_lSup cp_i cn_i '1.0'
  R2 cp_i net34 R='50'
  R25 cn_i net059 R='50'
  XI16 bin_o bin_no diff_o va_comparator hysteresis='0.025' trf='3e-11' del='0' vhigh='1.5'
  XI14 net059 net039 S0_i inh_lSup va_relay
  XI8 net34 net039 S0_i inh_lSup va_relay
  C0 net039 inh_lSup C='14p'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: bandgap_testbench
** Cell name: bandgap
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT bandgap bg_out disable inh_bulkn inh_bulkpanalog inh_hsupanalog inh_lSup
  M78 inh_lSup inh_lSup inh_hsupanalog inh_bulkn NANA W='400n' L='400n' M='1'
  M77 inh_lSup inh_lSup bg_out inh_bulkn NANA W='400n' L='400n' M='1'
  M74 net016 net011 inh_lSup inh_bulkn NANA W='400n' L='400n' M='1'
  M73 net074 net064 net019 inh_bulkn NANA W='400n' L='400n' M='1'
  M62 bg_out net011 inh_lSup inh_bulkn NANA W='400n' L='400n' M='1'
  M65 net013 net011 inh_lSup inh_bulkn NANA W='400n' L='400n' M='1'
  M68 net013 net064 net070 inh_bulkn NANA W='400n' L='400n' M='1'
  M69 net069 net016 inh_lSup inh_bulkn NANA W='400n' L='2.4u' M='4'
  M72 net016 net064 net0127 inh_bulkn NANA W='400n' L='400n' M='1'
  M47 net019 net019 inh_lSup inh_bulkn NANA W='400n' L='400n' M='1'
  M45 net029 net019 net41 inh_bulkn NANA W='400n' L='400n' M='2'
  M61 net011 net064 inh_lSup inh_bulkn NANA W='400n' L='400n' M='1'
  M49 net070 net013 inh_lSup inh_bulkn NANA W='400n' L='2.4u' M='1'
  M48 net0127 net013 inh_lSup inh_bulkn NANA W='400n' L='2.4u' M='1'
  M55 net064 disable inh_lSup inh_bulkn NANA W='400n' L='400n' M='1'
  M70 net011 net064 inh_hsupanalog inh_bulkpanalog PANA W='1.2u' L='400n' M='1'
  M80 net030 net011 net078 inh_bulkpanalog PANA W='400n' L='400n' M='8'
  M60 net028 net077 net025 inh_bulkpanalog PANA W='400n' L='400n' M='1'
  M59 net029 net077 net030 inh_bulkpanalog PANA W='400n' L='400n' M='8'
  M85 net070 net012 net028 inh_bulkpanalog PANA W='400n' L='800n' M='4'
  M58 net0127 net0105 net028 inh_bulkpanalog PANA W='400n' L='800n' M='4'
  M90 net068 net064 inh_hsupanalog inh_bulkpanalog PANA W='400n' L='400n' M='8'
  M75 net077 net064 inh_hsupanalog inh_bulkpanalog PANA W='400n' L='400n' M='8'
  M89 net068 net077 net042 inh_bulkpanalog PANA W='400n' L='400n' M='2'
  M79 net029 net011 net077 inh_bulkpanalog PANA W='400n' L='400n' M='8'
  M84 net078 net064 inh_hsupanalog inh_bulkpanalog PANA W='400n' L='400n' M='8'
  M51 net39 net39 inh_hsupanalog inh_bulkpanalog PANA W='400n' L='1.2u' M='1'
  M81 net076 net076 net39 inh_bulkpanalog PANA W='400n' L='1.2u' M='1'
  M82 net074 net074 net076 inh_bulkpanalog PANA W='400n' L='1.2u' M='1'
  M50 net074 net078 inh_hsupanalog inh_bulkpanalog PANA W='400n' L='400n' M='1'
  M27 net030 net078 inh_hsupanalog inh_bulkpanalog PANA W='400n' L='400n' M='1'
  M71 bg_out net011 net053 inh_bulkpanalog PANA W='400n' L='400n' M='8'
  M56 net025 net078 inh_hsupanalog inh_bulkpanalog PANA W='400n' L='400n' M='1'
  M88 net042 net078 inh_hsupanalog inh_bulkpanalog PANA W='400n' L='400n' M='2'
  M63 net053 net068 inh_hsupanalog inh_bulkpanalog PANA W='400n' L='400n' M='8'
  M86 net039 net068 inh_hsupanalog inh_bulkpanalog PANA W='400n' L='400n' M='4'
  M87 net040 net068 inh_hsupanalog inh_bulkpanalog PANA W='400n' L='400n' M='4'
  M76 net069 net011 net068 inh_bulkpanalog PANA W='400n' L='400n' M='8'
  M83 net064 disable inh_hsupanalog inh_bulkpanalog PANA W='1.2u' L='400n' M='1'
  R248 net050 net0102 R='10K'
  R247 net0102 net0105 R='10K'
  R246 net0102 net038 R='10K'
  R233 net038 net0105 R='10K'
  R245 net0100 net0101 R='10K'
  R244 net0101 net051 R='10K'
  R243 net051 net038 R='10K'
  R242 net0100 net055 R='10K'
  R241 net055 net054 R='10K'
  R278 net053 net0132 R='10K'
  R249 net050 net099 R='10K'
  R277 net0120 net0126 R='10K'
  R276 net0136 net0120 R='10K'
  R275 net0136 net0117 R='10K'
  R263 net0133 net0135 R='10K'
  R262 net0114 net0131 R='10K'
  R261 net0121 net0134 R='10K'
  R260 net0122 net062 R='10K'
  R250 net099 net049 R='10K'
  R255 net053 net045 R='10K'
  R240 net054 net056 R='10K'
  R239 net059 net058 R='10K'
  R254 net046 net047 R='10K'
  R253 net045 net046 R='10K'
  R274 net0126 net0137 R='10K'
  R273 net0132 net0123 R='10K'
  R259 net0129 net0133 R='10K'
  R258 net0128 net0114 R='10K'
  R272 net0117 net041 R='10K'
  R271 net0117 net012 R='10K'
  R270 net0137 net0125 R='10K'
  R269 net0123 net0125 R='10K'
  R268 net041 net012 R='10K'
  R267 net0118 net0129 R='10K'
  R266 net0131 net0135 R='10K'
  R265 net0134 net041 R='10K'
  R238 net058 net057 R='10K'
  R237 net057 net056 R='10K'
  R252 net048 net047 R='10K'
  R251 net049 net048 R='10K'
  R236 net061 net0105 R='10K'
  R11 net41 inh_lSup R='50K'
  R235 net060 net061 R='10K'
  R257 net0128 net0121 R='10K'
  R264 net062 net012 R='10K'
  R0 net0105 net052 R='10K'
  R256 net0118 net0122 R='10K'
  R234 net059 net060 R='10K'
  C2 net069 net0127 C='5f'
  C1 net069 net0127 C='5f'
  Q1 inh_lSup inh_lSup net012 inh_bulkn LATPNP
  Q0 inh_lSup inh_lSup net052 inh_bulkn LATPNP M='8'
  Q3 inh_lSup net012 net039 inh_bulkn LATPNP
  Q2 inh_lSup net052 net040 inh_bulkn LATPNP M='8'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_diff_buf2x0
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_diff_buf2x0 VDD VSS an ap zn zp inh_bulk_n inh_bulk_p
  MP2 zp an VDD inh_bulk_p PREG W='4.72u' L='120.0n' M='1'
  MP0 zp zn VDD inh_bulk_p PREG W='1.48u' L='120.0n' M='1'
  MP1 zn zp VDD inh_bulk_p PREG W='1.48u' L='120.0n' M='1'
  MP6 zn ap VDD inh_bulk_p PREG W='4.72u' L='120.0n' M='1'
  MN0 zp an VSS inh_bulk_n NREG W='2.96u' L='120.0n' M='1'
  MN6 zn ap VSS inh_bulk_n NREG W='2.96u' L='120.0n' M='1'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: ana_lib
** Cell name: DIODE
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT DIODE_X PLUS MINUS inh_bulk_n
  Q1 MINUS MINUS PLUS inh_bulk_n LATPNP
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: NAND2XP
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT NAND2XP A B Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mntrans36 net25 B inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  Mntrans35 Z A net25 inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  MN1 net022 B inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  MN0 Z A net022 inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  Mptrans38 Z B inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  Mptrans37 Z A inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='5.4e-12'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_spare_nand2xp
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_spare_nand2xp VDD VSS a_i b_i nc_dummy_out inh_bulk_n inh_bulk_p
  XI2 net4 net4 nc_dummy_out inh_bulk_n inh_bulk_p VDD VSS NAND2XP
  XI1 a_i b_i net4 inh_bulk_n inh_bulk_p VDD VSS NAND2XP
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: ana_lib
** Cell name: sub_diode
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT sub_diode MINUS PLUS inh_bulk_n
  Q1 MINUS MINUS PLUS inh_bulk_n LATPNP
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: TIEZERO
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT TIEZERO Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mptrans10 netcheck_mark netcheck_mark inh_hSup inh_bulk_p PREG W='860.0n' L='120.0n' M='1'
  Mntrans11 Z netcheck_mark inh_lSup inh_bulk_n NREG W='400n' L='120.0n' M='1'
  XINSTANCE1 inh_hSup inh_lSup inh_bulk_n sub_diode
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: AND2
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT AND2 A B Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mptrans25 Z net39 inh_hSup inh_bulk_p PREG W='860.0n' L='120.0n' M='1'
  Mptrans24 net39 A inh_hSup inh_bulk_p PREG W='700n' L='120.0n' M='1'
  Mptrans23 net39 B inh_hSup inh_bulk_p PREG W='700n' L='120.0n' M='1'
  Mntrans22 Z net39 inh_lSup inh_bulk_n NREG W='600n' L='120.0n' M='1'
  Mntrans21 net39 A net32 inh_bulk_n NREG W='700n' L='120.0n' M='1'
  Mntrans20 net32 B inh_lSup inh_bulk_n NREG W='700n' L='120.0n' M='1'
  XINSTANCE1 inh_hSup inh_lSup inh_bulk_n sub_diode
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: INV1
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT INV1 A Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mptrans10 Z A inh_hSup inh_bulk_p PREG W='860.0n' L='120.0n' M='1'
  Mntrans11 Z A inh_lSup inh_bulk_n NREG W='600n' L='120.0n' M='1'
  XINSTANCE1 inh_hSup inh_lSup inh_bulk_n sub_diode
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: AND4
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT AND4 A B C D Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mptrans84 Z net49 inh_hSup inh_bulk_p PREG W='860.0n' L='120.0n' M='1'
  Mptrans83 net49 D inh_hSup inh_bulk_p PREG W='700n' L='120.0n' M='1'
  Mptrans82 net49 B inh_hSup inh_bulk_p PREG W='700n' L='120.0n' M='1'
  Mptrans81 net49 A inh_hSup inh_bulk_p PREG W='700n' L='120.0n' M='1'
  Mptrans80 net49 C inh_hSup inh_bulk_p PREG W='700n' L='120.0n' M='1'
  Mntrans89 Z net49 inh_lSup inh_bulk_n NREG W='600n' L='120.0n' M='1'
  Mntrans88 net45 D inh_lSup inh_bulk_n NREG W='900n' L='120.0n' M='1'
  Mntrans87 net49 A net39 inh_bulk_n NREG W='900n' L='120.0n' M='1'
  Mntrans86 net39 B net36 inh_bulk_n NREG W='900n' L='120.0n' M='1'
  Mntrans85 net36 C net45 inh_bulk_n NREG W='900n' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='6.3e-12'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_anamux_mux_dec
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_anamux_mux_dec VDD VSS dec_out<10> dec_out<9> dec_out<8> dec_out<7> dec_out<6> dec_out<5> dec_out<4> dec_out<3> dec_out<2> dec_out<1> dec_out<0> en_i sel_i<3> sel_i<2> sel_i<1> sel_i<0> inh_bulk_n inh_bulk_p
  XI50 net072 en_i dec_out<10> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI41 net064 en_i dec_out<1> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI42 net065 en_i dec_out<2> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI43 net066 en_i dec_out<3> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI44 net067 en_i dec_out<4> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI45 net068 en_i dec_out<5> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI49 net071 en_i dec_out<9> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI48 net070 en_i dec_out<8> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI22 net8 en_i dec_out<0> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI47 net073 en_i dec_out<7> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI46 net069 en_i dec_out<6> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI100<3> sel_i<3> sel_n_s<3> inh_bulk_n inh_bulk_p VDD VSS INV1
  XI100<2> sel_i<2> sel_n_s<2> inh_bulk_n inh_bulk_p VDD VSS INV1
  XI100<1> sel_i<1> sel_n_s<1> inh_bulk_n inh_bulk_p VDD VSS INV1
  XI100<0> sel_i<0> sel_n_s<0> inh_bulk_n inh_bulk_p VDD VSS INV1
  XI30 sel_n_s<3> sel_n_s<2> sel_n_s<1> sel_n_s<0> net8 inh_bulk_n inh_bulk_p VDD VSS AND4
  XI37 sel_i<3> sel_n_s<2> sel_n_s<1> sel_n_s<0> net070 inh_bulk_n inh_bulk_p VDD VSS AND4
  XI40 sel_n_s<3> sel_i<2> sel_i<1> sel_i<0> net073 inh_bulk_n inh_bulk_p VDD VSS AND4
  XI39 sel_i<3> sel_n_s<2> sel_i<1> sel_n_s<0> net072 inh_bulk_n inh_bulk_p VDD VSS AND4
  XI38 sel_i<3> sel_n_s<2> sel_n_s<1> sel_i<0> net071 inh_bulk_n inh_bulk_p VDD VSS AND4
  XI34 sel_n_s<3> sel_i<2> sel_n_s<1> sel_n_s<0> net067 inh_bulk_n inh_bulk_p VDD VSS AND4
  XI31 sel_n_s<3> sel_n_s<2> sel_n_s<1> sel_i<0> net064 inh_bulk_n inh_bulk_p VDD VSS AND4
  XI32 sel_n_s<3> sel_n_s<2> sel_i<1> sel_n_s<0> net065 inh_bulk_n inh_bulk_p VDD VSS AND4
  XI33 sel_n_s<3> sel_n_s<2> sel_i<1> sel_i<0> net066 inh_bulk_n inh_bulk_p VDD VSS AND4
  XI36 sel_n_s<3> sel_i<2> sel_i<1> sel_n_s<0> net069 inh_bulk_n inh_bulk_p VDD VSS AND4
  XI35 sel_n_s<3> sel_i<2> sel_n_s<1> sel_i<0> net068 inh_bulk_n inh_bulk_p VDD VSS AND4
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_anamux_sw_half2
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_anamux_sw_half2 VDD VSS en_1v5 sw_in sw_out inh_bulk_n inh_bulk_p
  MP0 sw_out net5 sw_in inh_bulk_p PANA W='7u' L='400n' M='1'
  MP1 net5 en_1v5 VDD inh_bulk_p PANA W='680.0n' L='400n' M='1'
  MN0 sw_out en_1v5 sw_in inh_bulk_n NANA W='3.52u' L='400n' M='1'
  MN1 net5 en_1v5 VSS inh_bulk_n NANA W='680.0n' L='400n' M='1'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_dc_testout
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_dc_testout VDD VSS ana_test_out dec_o<10> dec_o<9> dec_o<8> dec_o<7> dec_o<6> dec_o<5> dec_o<4> dec_o<3> dec_o<2> dec_o<1> dec_o<0> en_i in_0 in_1 in_2 in_3 in_4 in_5 in_6 in_7 in_8 in_9 in_10 sel_i<3> sel_i<2> sel_i<1> sel_i<0> inh_bulk_n inh_bulk_p
  XI30 VDD VSS dec_o<10> dec_o<9> dec_o<8> dec_o<7> dec_o<6> dec_o<5> dec_o<4> dec_o<3> dec_o<2> dec_o<1> dec_o<0> en_i sel_i<3> sel_i<2> sel_i<1> sel_i<0> inh_bulk_n inh_bulk_p phy_anamux_mux_dec
  MN0 net20 en_i VSS inh_bulk_n NANA W='680.0n' L='400n' M='1'
  MN1 ana_test_out net20 VSS inh_bulk_n NANA W='2u' L='400n' M='1'
  XI19 VDD VSS dec_o<9> in_9 ana_test_out inh_bulk_n inh_bulk_p phy_anamux_sw_half2
  XI18 VDD VSS dec_o<8> in_8 ana_test_out inh_bulk_n inh_bulk_p phy_anamux_sw_half2
  XI16 VDD VSS dec_o<7> in_7 ana_test_out inh_bulk_n inh_bulk_p phy_anamux_sw_half2
  XI44 VDD VSS dec_o<4> in_4 ana_test_out inh_bulk_n inh_bulk_p phy_anamux_sw_half2
  XI40 VDD VSS dec_o<1> in_1 ana_test_out inh_bulk_n inh_bulk_p phy_anamux_sw_half2
  XI31 VDD VSS dec_o<0> in_0 ana_test_out inh_bulk_n inh_bulk_p phy_anamux_sw_half2
  XI41 VDD VSS dec_o<2> in_2 ana_test_out inh_bulk_n inh_bulk_p phy_anamux_sw_half2
  XI42 VDD VSS dec_o<3> in_3 ana_test_out inh_bulk_n inh_bulk_p phy_anamux_sw_half2
  XI14 VDD VSS dec_o<6> in_6 ana_test_out inh_bulk_n inh_bulk_p phy_anamux_sw_half2
  XI45 VDD VSS dec_o<5> in_5 ana_test_out inh_bulk_n inh_bulk_p phy_anamux_sw_half2
  XI20 VDD VSS dec_o<10> in_10 ana_test_out inh_bulk_n inh_bulk_p phy_anamux_sw_half2
  MP1 net20 en_i VDD inh_bulk_p PANA W='680.0n' L='400n' M='1'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: NAND2
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT NAND2 A B Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mptrans38 Z B inh_hSup inh_bulk_p PREG W='860.0n' L='120.0n' M='1'
  Mptrans37 Z A inh_hSup inh_bulk_p PREG W='860.0n' L='120.0n' M='1'
  Mntrans36 net25 B inh_lSup inh_bulk_n NREG W='860.0n' L='120.0n' M='1'
  Mntrans35 Z A net25 inh_bulk_n NREG W='860.0n' L='120.0n' M='1'
  XINSTANCE1 inh_hSup inh_lSup inh_bulk_n sub_diode
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_spare_nand2
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_spare_nand2 VDD VSS a_i b_i nc_dummy_out inh_bulk_n inh_bulk_p
  XI2 net4 net4 nc_dummy_out inh_bulk_n inh_bulk_p VDD VSS NAND2
  XI1 a_i b_i net4 inh_bulk_n inh_bulk_p VDD VSS NAND2
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: FDN2QNB
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT FDN2QNB CP D QN RN inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mntrans65 D1 D inh_lSup inh_bulk_n NREG W='800n' L='120.0n' M='1'
  Mntrans158 SF2 CP2 net206 inh_bulk_n NREG W='400n' L='120.0n' M='1'
  Mntrans128 MB2 MF1 inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  MN5 MF1 CP2 D1 inh_bulk_n NREG W='500n' L='120.0n' M='1'
  Mntrans156 net206 SB3 inh_lSup inh_bulk_n NREG W='400n' L='120.0n' M='1'
  Mntrans119 CP1 CP inh_lSup inh_bulk_n NREG W='650.0n' L='120.0n' M='1'
  Mntrans155 net0144 RN net200 inh_bulk_n NREG W='500n' L='120.0n' M='1'
  Mntrans154 net0144 CP1 MF1 inh_bulk_n NREG W='850.0n' L='120.0n' M='1'
  Mntrans123 CP2 CP1 inh_lSup inh_bulk_n NREG W='500n' L='120.0n' M='1'
  MN0 net158 RN inh_lSup inh_bulk_n NREG W='400n' L='120.0n' M='1'
  MN1 SB3 SF2 net158 inh_bulk_n NREG W='400n' L='120.0n' M='1'
  Mntrans153 net200 MB2 inh_lSup inh_bulk_n NREG W='500n' L='120.0n' M='1'
  MN3 SF2 CP1 MB2 inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  MN4 QN SF2 inh_lSup inh_bulk_n NREG W='2.24u' L='120.0n' M='1'
  Mptrans63 D1 D inh_hSup inh_bulk_p PREG W='1.2u' L='120.0n' M='1'
  Mptrans151 net0144 RN inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  Mptrans118 CP1 CP inh_hSup inh_bulk_p PREG W='900n' L='120.0n' M='1'
  MP4 SF2 CP1 net105 inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP6 MF1 CP1 D1 inh_bulk_p PREG W='500n' L='120.0n' M='1'
  Mptrans127 MB2 MF1 inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  Mptrans152 net0144 MB2 inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP1 SB3 SF2 inh_hSup inh_bulk_p PREG W='400n' L='120.0n' M='1'
  Mptrans122 CP2 CP1 inh_hSup inh_bulk_p PREG W='750.0n' L='120.0n' M='1'
  MP0 SB3 RN inh_hSup inh_bulk_p PREG W='400n' L='120.0n' M='1'
  Mptrans160 net105 SB3 inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  Mptrans150 net0144 CP2 MF1 inh_bulk_p PREG W='880.0n' L='120.0n' M='1'
  MP3 SF2 CP2 MB2 inh_bulk_p PREG W='1.12u' L='120.0n' M='1'
  MP5 QN SF2 inh_hSup inh_bulk_p PREG W='3.24u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='2.16e-11'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: FD2QV
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT FD2QV CP D Q RN inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mntrans65 D1 D inh_lSup inh_bulk_n NREG W='800n' L='120.0n' M='1'
  Mntrans158 SF2 CP1 net206 inh_bulk_n NREG W='400n' L='120.0n' M='1'
  Mntrans128 MB2 MF1 inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  MN5 MF1 CP1 D1 inh_bulk_n NREG W='500n' L='120.0n' M='1'
  Mntrans156 net206 SB3 inh_lSup inh_bulk_n NREG W='400n' L='120.0n' M='1'
  Mntrans119 CP1 CP inh_lSup inh_bulk_n NREG W='650.0n' L='120.0n' M='1'
  Mntrans155 net188 RN net200 inh_bulk_n NREG W='500n' L='120.0n' M='1'
  Mntrans154 MF1 CP2 net188 inh_bulk_n NREG W='500n' L='120.0n' M='1'
  Mntrans123 CP2 CP1 inh_lSup inh_bulk_n NREG W='500n' L='120.0n' M='1'
  MN0 net158 RN inh_lSup inh_bulk_n NREG W='400n' L='120.0n' M='1'
  MN1 SB3 SF2 net158 inh_bulk_n NREG W='400n' L='120.0n' M='1'
  Mntrans153 net200 MB2 inh_lSup inh_bulk_n NREG W='500n' L='120.0n' M='1'
  MN3 SF2 CP2 MB2 inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  Mntrans11 Q Q1 inh_lSup inh_bulk_n NREG W='4.48u' L='120.0n' M='1'
  MN4 Q1 SF2 inh_lSup inh_bulk_n NREG W='2.24u' L='120.0n' M='1'
  Mptrans63 D1 D inh_hSup inh_bulk_p PREG W='1.2u' L='120.0n' M='1'
  Mptrans151 net153 RN inh_hSup inh_bulk_p PREG W='1u' L='120.0n' M='1'
  Mptrans118 CP1 CP inh_hSup inh_bulk_p PREG W='900n' L='120.0n' M='1'
  MP4 SF2 CP2 net105 inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP6 MF1 CP2 D1 inh_bulk_p PREG W='500n' L='120.0n' M='1'
  Mptrans127 MB2 MF1 inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  Mptrans152 net153 MB2 inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP1 SB3 SF2 inh_hSup inh_bulk_p PREG W='400n' L='120.0n' M='1'
  Mptrans122 CP2 CP1 inh_hSup inh_bulk_p PREG W='750.0n' L='120.0n' M='1'
  MP0 SB3 RN inh_hSup inh_bulk_p PREG W='400n' L='120.0n' M='1'
  Mptrans160 net105 SB3 inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  Mptrans150 MF1 CP1 net153 inh_bulk_p PREG W='880.0n' L='120.0n' M='1'
  MP3 SF2 CP1 MB2 inh_bulk_p PREG W='1.12u' L='120.0n' M='1'
  Mptrans10 Q Q1 inh_hSup inh_bulk_p PREG W='6.48u' L='120.0n' M='1'
  MP5 Q1 SF2 inh_hSup inh_bulk_p PREG W='3.24u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='2.52e-11'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: INV4
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT INV4 A Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mptrans10 Z A inh_hSup inh_bulk_p PREG W='3.24u' L='120.0n' M='1'
  Mntrans11 Z A inh_lSup inh_bulk_n NREG W='2.24u' L='120.0n' M='1'
  XINSTANCE1 inh_hSup inh_lSup inh_bulk_n sub_diode
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: EXORB
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT EXORB A B Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  MN6 net096 B net095 inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  Mntrans4 net32 A inh_lSup inh_bulk_n NREG W='1.56u' L='120.0n' M='1'
  Mntrans12 net082 B inh_lSup inh_bulk_n NREG W='800n' L='120.0n' M='1'
  MN5 net095 net32 inh_lSup inh_bulk_n NREG W='900n' L='120.0n' M='1'
  MN4 Z net096 inh_lSup inh_bulk_n NREG W='2.24u' L='120.0n' M='1'
  MN7 net096 net082 net32 inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  MP5 net095 net32 inh_hSup inh_bulk_p PREG W='1.52u' L='120.0n' M='1'
  MP7 net096 B net32 inh_bulk_p PREG W='1.12u' L='120.0n' M='1'
  Mptrans3 net32 A inh_hSup inh_bulk_p PREG W='2.44u' L='120.0n' M='1'
  Mptrans11 net082 B inh_hSup inh_bulk_p PREG W='1.12u' L='120.0n' M='1'
  MP6 net096 net082 net095 inh_bulk_p PREG W='1.12u' L='120.0n' M='1'
  MP4 Z net096 inh_hSup inh_bulk_p PREG W='3.24u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='1.156e-11'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: INV3
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT INV3 A Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mptrans10 Z A inh_hSup inh_bulk_p PREG W='2.44u' L='120.0n' M='1'
  Mntrans11 Z A inh_lSup inh_bulk_n NREG W='1.7u' L='120.0n' M='1'
  XINSTANCE1 inh_hSup inh_lSup inh_bulk_n sub_diode
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: INV2
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT INV2 A Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mptrans10 Z A inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  Mntrans11 Z A inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  XINSTANCE1 inh_hSup inh_lSup inh_bulk_n sub_diode
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_clk_mux
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_clk_mux VDD VSS clk_n_o clk_p_o clkn_0_i clkn_1_i clkp_0_i clkp_1_i mux_iq_sel inh_bulk_n inh_bulk_p
  XI8 clkp_0_i net18 net26 inh_bulk_n inh_bulk_p VDD VSS NAND2
  XI4 clkn_1_i net20 net23 inh_bulk_n inh_bulk_p VDD VSS NAND2
  XI7 clkn_0_i net18 net24 inh_bulk_n inh_bulk_p VDD VSS NAND2
  XI2 clkp_1_i net20 net25 inh_bulk_n inh_bulk_p VDD VSS NAND2
  XI5 net24 net23 net27 inh_bulk_n inh_bulk_p VDD VSS NAND2XP
  XI3 net26 net25 net28 inh_bulk_n inh_bulk_p VDD VSS NAND2XP
  XI10 mux_iq_sel net18 inh_bulk_n inh_bulk_p VDD VSS INV3
  XI125 VDD VSS net27 net28 clk_n_o clk_p_o inh_bulk_n inh_bulk_p phy_diff_buf2x0
  XI9 net18 net20 inh_bulk_n inh_bulk_p VDD VSS INV2
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: FD2Q
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT FD2Q CP D Q RN inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mntrans65 D1 D inh_lSup inh_bulk_n NREG W='440.0n' L='120.0n' M='1'
  Mntrans158 SF2 CP1 net206 inh_bulk_n NREG W='400n' L='120.0n' M='1'
  Mntrans128 MB2 MF1 inh_lSup inh_bulk_n NREG W='560.0n' L='120.0n' M='1'
  MN5 MF1 CP1 D1 inh_bulk_n NREG W='300n' L='120.0n' M='1'
  Mntrans156 net206 SB3 inh_lSup inh_bulk_n NREG W='400n' L='120.0n' M='1'
  Mntrans119 CP1 CP inh_lSup inh_bulk_n NREG W='500n' L='120.0n' M='1'
  Mntrans155 net188 RN net200 inh_bulk_n NREG W='500n' L='120.0n' M='1'
  Mntrans154 MF1 CP2 net188 inh_bulk_n NREG W='500n' L='120.0n' M='1'
  Mntrans123 CP2 CP1 inh_lSup inh_bulk_n NREG W='420.0n' L='120.0n' M='1'
  MN0 net158 RN inh_lSup inh_bulk_n NREG W='700n' L='120.0n' M='1'
  MN1 SB3 SF2 net158 inh_bulk_n NREG W='700n' L='120.0n' M='1'
  Mntrans153 net200 MB2 inh_lSup inh_bulk_n NREG W='500n' L='120.0n' M='1'
  MN3 SF2 CP2 MB2 inh_bulk_n NREG W='660.0n' L='120.0n' M='1'
  MN4 Q SB3 inh_lSup inh_bulk_n NREG W='600n' L='120.0n' M='1'
  Mptrans63 D1 D inh_hSup inh_bulk_p PREG W='640.0n' L='120.0n' M='1'
  Mptrans151 net153 RN inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  Mptrans118 CP1 CP inh_hSup inh_bulk_p PREG W='700n' L='120.0n' M='1'
  MP4 SF2 CP2 net105 inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP6 MF1 CP2 D1 inh_bulk_p PREG W='300n' L='120.0n' M='1'
  Mptrans127 MB2 MF1 inh_hSup inh_bulk_p PREG W='800n' L='120.0n' M='1'
  Mptrans152 net153 MB2 inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP1 SB3 SF2 inh_hSup inh_bulk_p PREG W='900n' L='120.0n' M='1'
  Mptrans122 CP2 CP1 inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP0 SB3 RN inh_hSup inh_bulk_p PREG W='900n' L='120.0n' M='1'
  Mptrans160 net105 SB3 inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  Mptrans150 MF1 CP1 net153 inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP3 SF2 CP1 MB2 inh_bulk_p PREG W='660.0n' L='120.0n' M='1'
  MP5 Q SB3 inh_hSup inh_bulk_p PREG W='860.0n' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='1.98e-11'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: SYNFD2
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT SYNFD2 CP D Q RN inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mntrans65 D1 D inh_lSup inh_bulk_n NREG W='440.0n' L='120.0n' M='1'
  Mntrans158 Y32 CP1 net206 inh_bulk_n NREG W='400n' L='120.0n' M='1'
  Mntrans128 Y22 Y11 inh_lSup inh_bulk_n NREG W='560.0n' L='120.0n' M='1'
  MN5 Y11 CP1 D1 inh_bulk_n NREG W='300n' L='120.0n' M='1'
  Mntrans156 net206 Y43 inh_lSup inh_bulk_n NREG W='400n' L='120.0n' M='1'
  Mntrans119 CP1 CP inh_lSup inh_bulk_n NREG W='500n' L='120.0n' M='1'
  Mntrans155 net188 RN net200 inh_bulk_n NREG W='500n' L='120.0n' M='1'
  Mntrans154 Y11 CP2 net188 inh_bulk_n NREG W='500n' L='120.0n' M='1'
  Mntrans123 CP2 CP1 inh_lSup inh_bulk_n NREG W='420.0n' L='120.0n' M='1'
  MN0 net158 RN inh_lSup inh_bulk_n NREG W='700n' L='120.0n' M='1'
  MN1 Y43 Y32 net158 inh_bulk_n NREG W='700n' L='120.0n' M='1'
  MN19 IQN1 IQ1 inh_lSup inh_bulk_n NREG W='560.0n' L='120.0n' M='1'
  MN18 Y76 CP1_2 net0202 inh_bulk_n NREG W='400n' L='120.0n' M='1'
  MN17 Y66 Y55 inh_lSup inh_bulk_n NREG W='700n' L='120.0n' M='1'
  MN16 Y55 CP1_2 IQN1 inh_bulk_n NREG W='400n' L='120.0n' M='1'
  MN15 net0202 Y87 inh_lSup inh_bulk_n NREG W='400n' L='120.0n' M='1'
  Mntrans153 net200 Y22 inh_lSup inh_bulk_n NREG W='500n' L='120.0n' M='1'
  MN3 Y32 CP2 Y22 inh_bulk_n NREG W='660.0n' L='120.0n' M='1'
  MN14 CP1_2 CP inh_lSup inh_bulk_n NREG W='560.0n' L='120.0n' M='1'
  MN13 net0205 RN net0217 inh_bulk_n NREG W='500n' L='120.0n' M='1'
  MN12 Y55 CP2_2 net0205 inh_bulk_n NREG W='500n' L='120.0n' M='1'
  MN11 CP2_2 CP1_2 inh_lSup inh_bulk_n NREG W='460.0n' L='120.0n' M='1'
  MN10 net0211 RN inh_lSup inh_bulk_n NREG W='1u' L='120.0n' M='1'
  MN9 Y87 Y76 net0211 inh_bulk_n NREG W='1u' L='120.0n' M='1'
  MN8 net0217 Y66 inh_lSup inh_bulk_n NREG W='500n' L='120.0n' M='1'
  MN7 Y76 CP2_2 Y66 inh_bulk_n NREG W='800n' L='120.0n' M='1'
  MN6 Q Y87 inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  MN4 IQ1 Y43 inh_lSup inh_bulk_n NREG W='600n' L='120.0n' M='1'
  Mptrans63 D1 D inh_hSup inh_bulk_p PREG W='640.0n' L='120.0n' M='1'
  Mptrans151 net153 RN inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  Mptrans118 CP1 CP inh_hSup inh_bulk_p PREG W='700n' L='120.0n' M='1'
  MP4 Y32 CP2 net105 inh_bulk_p PREG W='640.0n' L='120.0n' M='1'
  MP6 Y11 CP2 D1 inh_bulk_p PREG W='300n' L='120.0n' M='1'
  Mptrans127 Y22 Y11 inh_hSup inh_bulk_p PREG W='800n' L='120.0n' M='1'
  Mptrans152 net153 Y22 inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP1 Y43 Y32 inh_hSup inh_bulk_p PREG W='900n' L='120.0n' M='1'
  Mptrans122 CP2 CP1 inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP0 Y43 RN inh_hSup inh_bulk_p PREG W='900n' L='120.0n' M='1'
  Mptrans160 net105 Y43 inh_hSup inh_bulk_p PREG W='640.0n' L='120.0n' M='1'
  Mptrans150 Y11 CP1 net153 inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP3 Y32 CP1 Y22 inh_bulk_p PREG W='660.0n' L='120.0n' M='1'
  MP20 IQN1 IQ1 inh_hSup inh_bulk_p PREG W='800n' L='120.0n' M='1'
  MP19 net0108 RN inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP18 CP1_2 CP inh_hSup inh_bulk_p PREG W='800n' L='120.0n' M='1'
  MP7 Q Y87 inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  MP5 IQ1 Y43 inh_hSup inh_bulk_p PREG W='860.0n' L='120.0n' M='1'
  MP17 Y76 CP2_2 net0112 inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP16 Y55 CP2_2 IQN1 inh_bulk_p PREG W='400n' L='120.0n' M='1'
  MP15 Y66 Y55 inh_hSup inh_bulk_p PREG W='1u' L='120.0n' M='1'
  MP14 net0108 Y66 inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP13 Y87 Y76 inh_hSup inh_bulk_p PREG W='1.2u' L='120.0n' M='1'
  MP12 CP2_2 CP1_2 inh_hSup inh_bulk_p PREG W='660.0n' L='120.0n' M='1'
  MP11 Y87 RN inh_hSup inh_bulk_p PREG W='1.2u' L='120.0n' M='1'
  MP10 net0112 Y87 inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP8 Y76 CP1_2 Y66 inh_bulk_p PREG W='800n' L='120.0n' M='1'
  MP9 Y55 CP1_2 net0108 inh_bulk_p PREG W='600n' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='3.96e-11'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: TIEONE
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT TIEONE Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mptrans10 Z netcheck_mark inh_hSup inh_bulk_p PREG W='860.0n' L='120.0n' M='1'
  Mntrans11 netcheck_mark netcheck_mark inh_lSup inh_bulk_n NREG W='400n' L='120.0n' M='1'
  XINSTANCE1 inh_hSup inh_lSup inh_bulk_n sub_diode
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: AND2I
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT AND2I A B Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mptrans17 Z net35 net44 inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  Mptrans16 net44 A inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  Mptrans10 net35 B inh_hSup inh_bulk_p PREG W='1.28u' L='120.0n' M='1'
  Mntrans19 Z net35 inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  Mntrans18 Z A inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  Mntrans11 net35 B inh_lSup inh_bulk_n NREG W='900n' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='4.5e-12'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: NAND2B
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT NAND2B A B Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mntrans36 net25 B inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  Mntrans35 Z A net25 inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  MN1 net022 B inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  MN0 Z A net022 inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  Mptrans38 Z B inh_hSup inh_bulk_p PREG W='3.24u' L='120.0n' M='1'
  Mptrans37 Z A inh_hSup inh_bulk_p PREG W='3.24u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='5.4e-12'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: EXOR
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT EXOR A B Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mptrans26 net5 net125 inh_hSup inh_bulk_p PREG W='1.32u' L='120.0n' M='1'
  Mptrans27 Z B net5 inh_bulk_p PREG W='1.32u' L='120.0n' M='1'
  Mptrans3 net125 A inh_hSup inh_bulk_p PREG W='1.28u' L='120.0n' M='1'
  Mptrans11 net26 B inh_hSup inh_bulk_p PREG W='1.28u' L='120.0n' M='1'
  Mptrans18 Z A net14 inh_bulk_p PREG W='1.32u' L='120.0n' M='1'
  Mptrans22 net14 net26 inh_hSup inh_bulk_p PREG W='1.32u' L='120.0n' M='1'
  Mntrans29 Z net26 net22 inh_bulk_n NREG W='920.0n' L='120.0n' M='1'
  Mntrans28 net22 net125 inh_lSup inh_bulk_n NREG W='920.0n' L='120.0n' M='1'
  Mntrans4 net125 A inh_lSup inh_bulk_n NREG W='900n' L='120.0n' M='1'
  Mntrans12 net26 B inh_lSup inh_bulk_n NREG W='900n' L='120.0n' M='1'
  Mntrans19 Z A net28 inh_bulk_n NREG W='920.0n' L='120.0n' M='1'
  Mntrans23 net28 B inh_lSup inh_bulk_n NREG W='920.0n' L='120.0n' M='1'
  XINSTANCE1 inh_hSup inh_lSup inh_bulk_n sub_diode
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_clk
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_clk VDD VSS ck50m4iq_n_i ck50m4iq_p_i clk_0_o clk_90_o clk_180_o clk_270_o clk_dphy_0_i clk_dphy_90_i clk_dphy_180_i clk_dphy_270_i en_clk_dphy_i n_mux_iq_sel_i rstn_i sel_dr_i inh_bulk_n inh_bulk_p
  XI69 clk_dphy_90_i a net052 rstn_i inh_bulk_n inh_bulk_p VDD VSS FDN2QNB
  XI75 clk_dphy_270_i a d rstn_i inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI74 clk_dphy_0_i net049 a rstn_i inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI91 clk_180_ss net089 net063 net064 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI89 clk_0_ss net056 net090 net064 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI93 clk_90_ss net092 net082 net064 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI92 clk_270_ss net068 net070 net064 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI71 clk_dphy_180_i a net046 rstn_i inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI104 net066 inh_bulk_n inh_bulk_p VDD VSS TIEZERO
  XI97 net091 inh_bulk_n inh_bulk_p VDD VSS TIEZERO
  XI107 net092 inh_bulk_n inh_bulk_p VDD VSS TIEZERO
  XI85 net058 inh_bulk_n inh_bulk_p VDD VSS TIEZERO
  XI94 net068 inh_bulk_n inh_bulk_p VDD VSS TIEZERO
  XI70 net052 b inh_bulk_n inh_bulk_p VDD VSS INV4
  XI99 net073 net090 clk_90_div2_s inh_bulk_n inh_bulk_p VDD VSS EXORB
  XI98 net091 net090 clk_270_div2_s inh_bulk_n inh_bulk_p VDD VSS EXORB
  XI151 net073 net063 clk_0_div2_s inh_bulk_n inh_bulk_p VDD VSS EXORB
  XI154 net091 net063 clk_180_div2_s inh_bulk_n inh_bulk_p VDD VSS EXORB
  XI87 VDD VSS clk_180_o clk_0_o clk_180_ss clk_180_div2_s clk_0_ss clk_0_div2_s net040 inh_bulk_n inh_bulk_p phy_clk_mux
  XI86 VDD VSS clk_270_o clk_90_o clk_270_ss clk_270_div2_s clk_90_ss clk_90_div2_s net040 inh_bulk_n inh_bulk_p phy_clk_mux
  XI2 VDD VSS clk_180_ss clk_0_ss clk_180_s clk_50meg_180_s clk_0_s clk_50meg_0_s n_mux_iq_sel_i inh_bulk_n inh_bulk_p phy_clk_mux
  XI1 VDD VSS clk_270_ss clk_90_ss clk_270_s clk_50meg_270_s clk_90_s clk_50meg_90_s n_mux_iq_sel_i inh_bulk_n inh_bulk_p phy_clk_mux
  C17 clk_90_o VSS C='5f'
  C16 clk_180_o VSS C='5f'
  C15 clk_0_o VSS C='5f'
  C14 clk_270_o VSS C='5f'
  C13 a VSS C='10f'
  C12 clk_90_s VSS C='5f'
  C11 clk_270_s VSS C='5f'
  C10 clk_180_s VSS C='5f'
  C9 clk_0_s VSS C='5f'
  XI76 ck50m4iq_p_i net027 net053 rstn_i inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI78 ck50m4iq_n_i net057 net032 rstn_i inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI79 net032 net057 inh_bulk_n inh_bulk_p VDD VSS INV2
  XI77 net053 net027 inh_bulk_n inh_bulk_p VDD VSS INV2
  XI102 sel_dr_i net040 inh_bulk_n inh_bulk_p VDD VSS INV2
  XI96 net090 net056 inh_bulk_n inh_bulk_p VDD VSS INV1
  XI95 net063 net089 inh_bulk_n inh_bulk_p VDD VSS INV1
  XI6 clk_dphy_90_i en_clk_dphy_i net024 rstn_i inh_bulk_n inh_bulk_p VDD VSS SYNFD2
  XI5 clk_dphy_180_i en_clk_dphy_i net026 rstn_i inh_bulk_n inh_bulk_p VDD VSS SYNFD2
  XI4 clk_dphy_0_i en_clk_dphy_i net049 rstn_i inh_bulk_n inh_bulk_p VDD VSS SYNFD2
  XI7 clk_dphy_270_i en_clk_dphy_i net023 rstn_i inh_bulk_n inh_bulk_p VDD VSS SYNFD2
  XI106 net021 inh_bulk_n inh_bulk_p VDD VSS TIEONE
  XI105 net067 inh_bulk_n inh_bulk_p VDD VSS TIEONE
  XI100 net073 inh_bulk_n inh_bulk_p VDD VSS TIEONE
  XI44 net051 inh_bulk_n inh_bulk_p VDD VSS TIEONE
  XI101 sel_dr_i rstn_i net064 inh_bulk_n inh_bulk_p VDD VSS AND2I
  XI41 a net033 clk_0_s inh_bulk_n inh_bulk_p VDD VSS NAND2B
  XI40 d net044 clk_90_s inh_bulk_n inh_bulk_p VDD VSS NAND2B
  XI53 net051 clk_dphy_0_i net033 inh_bulk_n inh_bulk_p VDD VSS NAND2B
  XI51 net051 clk_dphy_90_i net044 inh_bulk_n inh_bulk_p VDD VSS NAND2B
  XI35 a clk_dphy_180_i net029 inh_bulk_n inh_bulk_p VDD VSS NAND2B
  XI52 net051 net029 clk_180_s inh_bulk_n inh_bulk_p VDD VSS NAND2B
  XI54 net051 net031 clk_270_s inh_bulk_n inh_bulk_p VDD VSS NAND2B
  XI32 d clk_dphy_270_i net031 inh_bulk_n inh_bulk_p VDD VSS NAND2B
  XI83 net021 net032 clk_50meg_90_s inh_bulk_n inh_bulk_p VDD VSS EXOR
  XI82 net066 net053 clk_50meg_0_s inh_bulk_n inh_bulk_p VDD VSS EXOR
  XI81 net067 net053 clk_50meg_180_s inh_bulk_n inh_bulk_p VDD VSS EXOR
  XI80 net058 net032 clk_50meg_270_s inh_bulk_n inh_bulk_p VDD VSS EXOR
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_ncap_200f
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_ncap_200f VSS a b
  C2 a b C='201.7f' W='5.87u' L='5.87u'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_vref_filter
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_vref_filter VSS vref1_ai vref1_ao vref2_ai vref2_ao
  R2 vref2_ao vref2_ai R='1K'
  R0 vref1_ao vref1_ai R='1K'
  Xc0<19> VSS net012 VSS phy_ncap_200f
  Xc0<18> VSS net012 VSS phy_ncap_200f
  Xc0<17> VSS net012 VSS phy_ncap_200f
  Xc0<16> VSS net012 VSS phy_ncap_200f
  Xc0<15> VSS net012 VSS phy_ncap_200f
  Xc0<14> VSS net012 VSS phy_ncap_200f
  Xc0<13> VSS net012 VSS phy_ncap_200f
  Xc0<12> VSS net012 VSS phy_ncap_200f
  Xc0<11> VSS net012 VSS phy_ncap_200f
  Xc0<10> VSS net012 VSS phy_ncap_200f
  Xc0<9> VSS net012 VSS phy_ncap_200f
  Xc0<8> VSS net012 VSS phy_ncap_200f
  Xc0<7> VSS net012 VSS phy_ncap_200f
  Xc0<6> VSS net012 VSS phy_ncap_200f
  Xc0<5> VSS net012 VSS phy_ncap_200f
  Xc0<4> VSS net012 VSS phy_ncap_200f
  Xc0<3> VSS net012 VSS phy_ncap_200f
  Xc0<2> VSS net012 VSS phy_ncap_200f
  Xc0<1> VSS net012 VSS phy_ncap_200f
  Xc0<0> VSS net012 VSS phy_ncap_200f
  Xc1<19> VSS net15 VSS phy_ncap_200f
  Xc1<18> VSS net15 VSS phy_ncap_200f
  Xc1<17> VSS net15 VSS phy_ncap_200f
  Xc1<16> VSS net15 VSS phy_ncap_200f
  Xc1<15> VSS net15 VSS phy_ncap_200f
  Xc1<14> VSS net15 VSS phy_ncap_200f
  Xc1<13> VSS net15 VSS phy_ncap_200f
  Xc1<12> VSS net15 VSS phy_ncap_200f
  Xc1<11> VSS net15 VSS phy_ncap_200f
  Xc1<10> VSS net15 VSS phy_ncap_200f
  Xc1<9> VSS net15 VSS phy_ncap_200f
  Xc1<8> VSS net15 VSS phy_ncap_200f
  Xc1<7> VSS net15 VSS phy_ncap_200f
  Xc1<6> VSS net15 VSS phy_ncap_200f
  Xc1<5> VSS net15 VSS phy_ncap_200f
  Xc1<4> VSS net15 VSS phy_ncap_200f
  Xc1<3> VSS net15 VSS phy_ncap_200f
  Xc1<2> VSS net15 VSS phy_ncap_200f
  Xc1<1> VSS net15 VSS phy_ncap_200f
  Xc1<0> VSS net15 VSS phy_ncap_200f
  VIMess1 vref2_ao net15 DC 0
  VIMess0 vref1_ao net012 DC 0
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: AND2P
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT AND2P A B Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mntrans22 Z net39 inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  Mntrans21 net39 A net32 inh_bulk_n NREG W='900n' L='120.0n' M='1'
  Mntrans20 net32 B inh_lSup inh_bulk_n NREG W='900n' L='120.0n' M='1'
  Mptrans25 Z net39 inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  Mptrans24 net39 A inh_hSup inh_bulk_p PREG W='1.28u' L='120.0n' M='1'
  Mptrans23 net39 B inh_hSup inh_bulk_p PREG W='1.28u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='4.5e-12'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_mipi_gpin_en
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_mipi_gpin_en VDD VSS g_o en_i g_i inh_bulk_n inh_bulk_p
  XI1 g_i en_i g_o inh_bulk_n inh_bulk_p VDD VSS AND2P
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: NAND2X
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT NAND2X A B Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mntrans36 net25 B inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  Mntrans35 Z A net25 inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  Mptrans38 Z B inh_hSup inh_bulk_p PREG W='1.28u' L='120.0n' M='1'
  Mptrans37 Z A inh_hSup inh_bulk_p PREG W='1.28u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='3.6e-12'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_mipi_gpin_pd
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_mipi_gpin_pd VDD VSS g_o en_i g_i inh_bulk_n inh_bulk_p
  XI30 g_i en_i net04 inh_bulk_n inh_bulk_p VDD VSS NAND2X
  XI4 net04 en_i g_o inh_bulk_n inh_bulk_p VDD VSS NAND2XP
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: INV24
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT INV24 A Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mptrans10 Z A inh_hSup inh_bulk_p PREG W='19.44u' L='120.0n' M='1'
  Mntrans11 Z A inh_lSup inh_bulk_n NREG W='13.44u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='1.44e-11'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: BUF24
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT BUF24 A Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mptrans15 net24 A inh_hSup inh_bulk_p PREG W='8.1u' L='120.0n' M='1'
  Mptrans14 Z net24 inh_hSup inh_bulk_p PREG W='19.44u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='2.07e-11'
  Mntrans13 net24 A inh_lSup inh_bulk_n NREG W='5.6u' L='120.0n' M='1'
  Mntrans12 Z net24 inh_lSup inh_bulk_n NREG W='13.44u' L='120.0n' M='1'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_mipi_gpin
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_mipi_gpin GNDD GNDPHY VDDD1V5 VDDPHY1V5 cl_bypass_delay_line_i cl_bypass_delay_line_o cl_delay_prog_i<2> cl_delay_prog_i<1> cl_delay_prog_i<0> cl_delay_prog_o<2> cl_delay_prog_o<1> cl_delay_prog_o<0> cl_dft_deser_en_i cl_dft_deser_en_o
+ cl_dft_hstx_data_lpbk_i<15> cl_dft_hstx_data_lpbk_i<14> cl_dft_hstx_data_lpbk_i<13> cl_dft_hstx_data_lpbk_i<12> cl_dft_hstx_data_lpbk_i<11> cl_dft_hstx_data_lpbk_i<10> cl_dft_hstx_data_lpbk_i<9> cl_dft_hstx_data_lpbk_i<8> cl_dft_hstx_data_lpbk_i<7>
+ cl_dft_hstx_data_lpbk_i<6> cl_dft_hstx_data_lpbk_i<5> cl_dft_hstx_data_lpbk_i<4> cl_dft_hstx_data_lpbk_i<3> cl_dft_hstx_data_lpbk_i<2> cl_dft_hstx_data_lpbk_i<1> cl_dft_hstx_data_lpbk_i<0> cl_dft_hstx_data_lpbk_o<15> cl_dft_hstx_data_lpbk_o<14>
+ cl_dft_hstx_data_lpbk_o<13> cl_dft_hstx_data_lpbk_o<12> cl_dft_hstx_data_lpbk_o<11> cl_dft_hstx_data_lpbk_o<10> cl_dft_hstx_data_lpbk_o<9> cl_dft_hstx_data_lpbk_o<8> cl_dft_hstx_data_lpbk_o<7> cl_dft_hstx_data_lpbk_o<6> cl_dft_hstx_data_lpbk_o<5>
+ cl_dft_hstx_data_lpbk_o<4> cl_dft_hstx_data_lpbk_o<3> cl_dft_hstx_data_lpbk_o<2> cl_dft_hstx_data_lpbk_o<1> cl_dft_hstx_data_lpbk_o<0> cl_dft_hstx_lower_path_en_i cl_dft_hstx_lower_path_en_o cl_dft_ser_test_in_en_i cl_dft_ser_test_in_en_o cl_dft_ser_test_n_i
+ cl_dft_ser_test_n_o cl_dft_ser_test_p_i cl_dft_ser_test_p_o cl_hs_ser_en_i cl_hs_ser_en_o cl_hstx_data_i<15> cl_hstx_data_i<14> cl_hstx_data_i<13> cl_hstx_data_i<12> cl_hstx_data_i<11> cl_hstx_data_i<10> cl_hstx_data_i<9> cl_hstx_data_i<8> cl_hstx_data_i<7>
+ cl_hstx_data_i<6> cl_hstx_data_i<5> cl_hstx_data_i<4> cl_hstx_data_i<3> cl_hstx_data_i<2> cl_hstx_data_i<1> cl_hstx_data_i<0> cl_hstx_data_o<15> cl_hstx_data_o<14> cl_hstx_data_o<13> cl_hstx_data_o<12> cl_hstx_data_o<11> cl_hstx_data_o<10> cl_hstx_data_o<9>
+ cl_hstx_data_o<8> cl_hstx_data_o<7> cl_hstx_data_o<6> cl_hstx_data_o<5> cl_hstx_data_o<4> cl_hstx_data_o<3> cl_hstx_data_o<2> cl_hstx_data_o<1> cl_hstx_data_o<0> cl_hstx_en_lptx_dis_i cl_hstx_en_lptx_dis_o cl_hstx_pwrdn_i cl_hstx_pwrdn_o cl_lptx_dn_i
+ cl_lptx_dn_o cl_lptx_dp_i cl_lptx_dp_o cl_lptx_en_i cl_lptx_en_o dft_ana_test_en_i dft_ana_test_en_o dft_ana_test_out_dphy_sel_i<3> dft_ana_test_out_dphy_sel_i<2> dft_ana_test_out_dphy_sel_i<1> dft_ana_test_out_dphy_sel_i<0> dft_ana_test_out_dphy_sel_o<3>
+ dft_ana_test_out_dphy_sel_o<2> dft_ana_test_out_dphy_sel_o<1> dft_ana_test_out_dphy_sel_o<0> dft_dphy_ocdldo_res_dis_i dft_dphy_ocdldo_res_dis_o dft_pll_clks_2_cl_en_i dft_pll_clks_2_cl_en_o dl0_bypass_delay_line_i dl0_bypass_delay_line_o dl0_delay_prog_i<2>
+ dl0_delay_prog_i<1> dl0_delay_prog_i<0> dl0_delay_prog_o<2> dl0_delay_prog_o<1> dl0_delay_prog_o<0> dl0_dft_deser_en_i dl0_dft_deser_en_o dl0_dft_hstx_data_lpbk_i<15> dl0_dft_hstx_data_lpbk_i<14> dl0_dft_hstx_data_lpbk_i<13> dl0_dft_hstx_data_lpbk_i<12>
+ dl0_dft_hstx_data_lpbk_i<11> dl0_dft_hstx_data_lpbk_i<10> dl0_dft_hstx_data_lpbk_i<9> dl0_dft_hstx_data_lpbk_i<8> dl0_dft_hstx_data_lpbk_i<7> dl0_dft_hstx_data_lpbk_i<6> dl0_dft_hstx_data_lpbk_i<5> dl0_dft_hstx_data_lpbk_i<4> dl0_dft_hstx_data_lpbk_i<3>
+ dl0_dft_hstx_data_lpbk_i<2> dl0_dft_hstx_data_lpbk_i<1> dl0_dft_hstx_data_lpbk_i<0> dl0_dft_hstx_data_lpbk_o<15> dl0_dft_hstx_data_lpbk_o<14> dl0_dft_hstx_data_lpbk_o<13> dl0_dft_hstx_data_lpbk_o<12> dl0_dft_hstx_data_lpbk_o<11> dl0_dft_hstx_data_lpbk_o<10>
+ dl0_dft_hstx_data_lpbk_o<9> dl0_dft_hstx_data_lpbk_o<8> dl0_dft_hstx_data_lpbk_o<7> dl0_dft_hstx_data_lpbk_o<6> dl0_dft_hstx_data_lpbk_o<5> dl0_dft_hstx_data_lpbk_o<4> dl0_dft_hstx_data_lpbk_o<3> dl0_dft_hstx_data_lpbk_o<2> dl0_dft_hstx_data_lpbk_o<1>
+ dl0_dft_hstx_data_lpbk_o<0> dl0_dft_hstx_lower_path_en_i dl0_dft_hstx_lower_path_en_o dl0_dft_ser_test_in_en_i dl0_dft_ser_test_in_en_o dl0_dft_ser_test_n_i dl0_dft_ser_test_n_o dl0_dft_ser_test_p_i dl0_dft_ser_test_p_o dl0_hs_ser_en_i dl0_hs_ser_en_o
+ dl0_hstx_data_i<15> dl0_hstx_data_i<14> dl0_hstx_data_i<13> dl0_hstx_data_i<12> dl0_hstx_data_i<11> dl0_hstx_data_i<10> dl0_hstx_data_i<9> dl0_hstx_data_i<8> dl0_hstx_data_i<7> dl0_hstx_data_i<6> dl0_hstx_data_i<5> dl0_hstx_data_i<4> dl0_hstx_data_i<3>
+ dl0_hstx_data_i<2> dl0_hstx_data_i<1> dl0_hstx_data_i<0> dl0_hstx_data_o<15> dl0_hstx_data_o<14> dl0_hstx_data_o<13> dl0_hstx_data_o<12> dl0_hstx_data_o<11> dl0_hstx_data_o<10> dl0_hstx_data_o<9> dl0_hstx_data_o<8> dl0_hstx_data_o<7> dl0_hstx_data_o<6>
+ dl0_hstx_data_o<5> dl0_hstx_data_o<4> dl0_hstx_data_o<3> dl0_hstx_data_o<2> dl0_hstx_data_o<1> dl0_hstx_data_o<0> dl0_hstx_en_lptx_dis_i dl0_hstx_en_lptx_dis_o dl0_hstx_pwrdn_i dl0_hstx_pwrdn_o dl0_lptx_dn_i dl0_lptx_dn_o dl0_lptx_dp_i dl0_lptx_dp_o
+ dl0_lptx_en_i dl0_lptx_en_o dl1_bypass_delay_line_i dl1_bypass_delay_line_o dl1_delay_prog_i<2> dl1_delay_prog_i<1> dl1_delay_prog_i<0> dl1_delay_prog_o<2> dl1_delay_prog_o<1> dl1_delay_prog_o<0> dl1_dft_deser_en_i dl1_dft_deser_en_o
+ dl1_dft_hstx_data_lpbk_i<15> dl1_dft_hstx_data_lpbk_i<14> dl1_dft_hstx_data_lpbk_i<13> dl1_dft_hstx_data_lpbk_i<12> dl1_dft_hstx_data_lpbk_i<11> dl1_dft_hstx_data_lpbk_i<10> dl1_dft_hstx_data_lpbk_i<9> dl1_dft_hstx_data_lpbk_i<8> dl1_dft_hstx_data_lpbk_i<7>
+ dl1_dft_hstx_data_lpbk_i<6> dl1_dft_hstx_data_lpbk_i<5> dl1_dft_hstx_data_lpbk_i<4> dl1_dft_hstx_data_lpbk_i<3> dl1_dft_hstx_data_lpbk_i<2> dl1_dft_hstx_data_lpbk_i<1> dl1_dft_hstx_data_lpbk_i<0> dl1_dft_hstx_data_lpbk_o<15> dl1_dft_hstx_data_lpbk_o<14>
+ dl1_dft_hstx_data_lpbk_o<13> dl1_dft_hstx_data_lpbk_o<12> dl1_dft_hstx_data_lpbk_o<11> dl1_dft_hstx_data_lpbk_o<10> dl1_dft_hstx_data_lpbk_o<9> dl1_dft_hstx_data_lpbk_o<8> dl1_dft_hstx_data_lpbk_o<7> dl1_dft_hstx_data_lpbk_o<6> dl1_dft_hstx_data_lpbk_o<5>
+ dl1_dft_hstx_data_lpbk_o<4> dl1_dft_hstx_data_lpbk_o<3> dl1_dft_hstx_data_lpbk_o<2> dl1_dft_hstx_data_lpbk_o<1> dl1_dft_hstx_data_lpbk_o<0> dl1_dft_hstx_lower_path_en_i dl1_dft_hstx_lower_path_en_o dl1_dft_ser_test_in_en_i dl1_dft_ser_test_in_en_o
+ dl1_dft_ser_test_n_i dl1_dft_ser_test_n_o dl1_dft_ser_test_p_i dl1_dft_ser_test_p_o dl1_hs_ser_en_i dl1_hs_ser_en_o dl1_hstx_data_i<15> dl1_hstx_data_i<14> dl1_hstx_data_i<13> dl1_hstx_data_i<12> dl1_hstx_data_i<11> dl1_hstx_data_i<10> dl1_hstx_data_i<9>
+ dl1_hstx_data_i<8> dl1_hstx_data_i<7> dl1_hstx_data_i<6> dl1_hstx_data_i<5> dl1_hstx_data_i<4> dl1_hstx_data_i<3> dl1_hstx_data_i<2> dl1_hstx_data_i<1> dl1_hstx_data_i<0> dl1_hstx_data_o<15> dl1_hstx_data_o<14> dl1_hstx_data_o<13> dl1_hstx_data_o<12>
+ dl1_hstx_data_o<11> dl1_hstx_data_o<10> dl1_hstx_data_o<9> dl1_hstx_data_o<8> dl1_hstx_data_o<7> dl1_hstx_data_o<6> dl1_hstx_data_o<5> dl1_hstx_data_o<4> dl1_hstx_data_o<3> dl1_hstx_data_o<2> dl1_hstx_data_o<1> dl1_hstx_data_o<0> dl1_hstx_en_lptx_dis_i
+ dl1_hstx_en_lptx_dis_o dl1_hstx_pwrdn_i dl1_hstx_pwrdn_o dl1_lptx_dn_i dl1_lptx_dn_o dl1_lptx_dp_i dl1_lptx_dp_o dl1_lptx_en_i dl1_lptx_en_o dl1_tx_byte_clk_i dl1_tx_byte_clk_o dl2_bypass_delay_line_i dl2_bypass_delay_line_o dl2_delay_prog_i<2>
+ dl2_delay_prog_i<1> dl2_delay_prog_i<0> dl2_delay_prog_o<2> dl2_delay_prog_o<1> dl2_delay_prog_o<0> dl2_dft_deser_en_i dl2_dft_deser_en_o dl2_dft_hstx_data_lpbk_i<15> dl2_dft_hstx_data_lpbk_i<14> dl2_dft_hstx_data_lpbk_i<13> dl2_dft_hstx_data_lpbk_i<12>
+ dl2_dft_hstx_data_lpbk_i<11> dl2_dft_hstx_data_lpbk_i<10> dl2_dft_hstx_data_lpbk_i<9> dl2_dft_hstx_data_lpbk_i<8> dl2_dft_hstx_data_lpbk_i<7> dl2_dft_hstx_data_lpbk_i<6> dl2_dft_hstx_data_lpbk_i<5> dl2_dft_hstx_data_lpbk_i<4> dl2_dft_hstx_data_lpbk_i<3>
+ dl2_dft_hstx_data_lpbk_i<2> dl2_dft_hstx_data_lpbk_i<1> dl2_dft_hstx_data_lpbk_i<0> dl2_dft_hstx_data_lpbk_o<15> dl2_dft_hstx_data_lpbk_o<14> dl2_dft_hstx_data_lpbk_o<13> dl2_dft_hstx_data_lpbk_o<12> dl2_dft_hstx_data_lpbk_o<11> dl2_dft_hstx_data_lpbk_o<10>
+ dl2_dft_hstx_data_lpbk_o<9> dl2_dft_hstx_data_lpbk_o<8> dl2_dft_hstx_data_lpbk_o<7> dl2_dft_hstx_data_lpbk_o<6> dl2_dft_hstx_data_lpbk_o<5> dl2_dft_hstx_data_lpbk_o<4> dl2_dft_hstx_data_lpbk_o<3> dl2_dft_hstx_data_lpbk_o<2> dl2_dft_hstx_data_lpbk_o<1>
+ dl2_dft_hstx_data_lpbk_o<0> dl2_dft_hstx_lower_path_en_i dl2_dft_hstx_lower_path_en_o dl2_dft_ser_test_in_en_i dl2_dft_ser_test_in_en_o dl2_dft_ser_test_n_i dl2_dft_ser_test_n_o dl2_dft_ser_test_p_i dl2_dft_ser_test_p_o dl2_hs_ser_en_i dl2_hs_ser_en_o
+ dl2_hstx_data_i<15> dl2_hstx_data_i<14> dl2_hstx_data_i<13> dl2_hstx_data_i<12> dl2_hstx_data_i<11> dl2_hstx_data_i<10> dl2_hstx_data_i<9> dl2_hstx_data_i<8> dl2_hstx_data_i<7> dl2_hstx_data_i<6> dl2_hstx_data_i<5> dl2_hstx_data_i<4> dl2_hstx_data_i<3>
+ dl2_hstx_data_i<2> dl2_hstx_data_i<1> dl2_hstx_data_i<0> dl2_hstx_data_o<15> dl2_hstx_data_o<14> dl2_hstx_data_o<13> dl2_hstx_data_o<12> dl2_hstx_data_o<11> dl2_hstx_data_o<10> dl2_hstx_data_o<9> dl2_hstx_data_o<8> dl2_hstx_data_o<7> dl2_hstx_data_o<6>
+ dl2_hstx_data_o<5> dl2_hstx_data_o<4> dl2_hstx_data_o<3> dl2_hstx_data_o<2> dl2_hstx_data_o<1> dl2_hstx_data_o<0> dl2_hstx_en_lptx_dis_i dl2_hstx_en_lptx_dis_o dl2_hstx_pwrdn_i dl2_hstx_pwrdn_o dl2_lptx_dn_i dl2_lptx_dn_o dl2_lptx_dp_i dl2_lptx_dp_o
+ dl2_lptx_en_i dl2_lptx_en_o dl3_bypass_delay_line_i dl3_bypass_delay_line_o dl3_delay_prog_i<2> dl3_delay_prog_i<1> dl3_delay_prog_i<0> dl3_delay_prog_o<2> dl3_delay_prog_o<1> dl3_delay_prog_o<0> dl3_dft_deser_en_i dl3_dft_deser_en_o
+ dl3_dft_hstx_data_lpbk_i<15> dl3_dft_hstx_data_lpbk_i<14> dl3_dft_hstx_data_lpbk_i<13> dl3_dft_hstx_data_lpbk_i<12> dl3_dft_hstx_data_lpbk_i<11> dl3_dft_hstx_data_lpbk_i<10> dl3_dft_hstx_data_lpbk_i<9> dl3_dft_hstx_data_lpbk_i<8> dl3_dft_hstx_data_lpbk_i<7>
+ dl3_dft_hstx_data_lpbk_i<6> dl3_dft_hstx_data_lpbk_i<5> dl3_dft_hstx_data_lpbk_i<4> dl3_dft_hstx_data_lpbk_i<3> dl3_dft_hstx_data_lpbk_i<2> dl3_dft_hstx_data_lpbk_i<1> dl3_dft_hstx_data_lpbk_i<0> dl3_dft_hstx_data_lpbk_o<15> dl3_dft_hstx_data_lpbk_o<14>
+ dl3_dft_hstx_data_lpbk_o<13> dl3_dft_hstx_data_lpbk_o<12> dl3_dft_hstx_data_lpbk_o<11> dl3_dft_hstx_data_lpbk_o<10> dl3_dft_hstx_data_lpbk_o<9> dl3_dft_hstx_data_lpbk_o<8> dl3_dft_hstx_data_lpbk_o<7> dl3_dft_hstx_data_lpbk_o<6> dl3_dft_hstx_data_lpbk_o<5>
+ dl3_dft_hstx_data_lpbk_o<4> dl3_dft_hstx_data_lpbk_o<3> dl3_dft_hstx_data_lpbk_o<2> dl3_dft_hstx_data_lpbk_o<1> dl3_dft_hstx_data_lpbk_o<0> dl3_dft_hstx_lower_path_en_i dl3_dft_hstx_lower_path_en_o dl3_dft_ser_test_in_en_i dl3_dft_ser_test_in_en_o
+ dl3_dft_ser_test_n_i dl3_dft_ser_test_n_o dl3_dft_ser_test_p_i dl3_dft_ser_test_p_o dl3_hs_ser_en_i dl3_hs_ser_en_o dl3_hstx_data_i<15> dl3_hstx_data_i<14> dl3_hstx_data_i<13> dl3_hstx_data_i<12> dl3_hstx_data_i<11> dl3_hstx_data_i<10> dl3_hstx_data_i<9>
+ dl3_hstx_data_i<8> dl3_hstx_data_i<7> dl3_hstx_data_i<6> dl3_hstx_data_i<5> dl3_hstx_data_i<4> dl3_hstx_data_i<3> dl3_hstx_data_i<2> dl3_hstx_data_i<1> dl3_hstx_data_i<0> dl3_hstx_data_o<15> dl3_hstx_data_o<14> dl3_hstx_data_o<13> dl3_hstx_data_o<12>
+ dl3_hstx_data_o<11> dl3_hstx_data_o<10> dl3_hstx_data_o<9> dl3_hstx_data_o<8> dl3_hstx_data_o<7> dl3_hstx_data_o<6> dl3_hstx_data_o<5> dl3_hstx_data_o<4> dl3_hstx_data_o<3> dl3_hstx_data_o<2> dl3_hstx_data_o<1> dl3_hstx_data_o<0> dl3_hstx_en_lptx_dis_i
+ dl3_hstx_en_lptx_dis_o dl3_hstx_pwrdn_i dl3_hstx_pwrdn_o dl3_lptx_dn_i dl3_lptx_dn_o dl3_lptx_dp_i dl3_lptx_dp_o dl3_lptx_en_i dl3_lptx_en_o dphy_pwrdn_i dphy_pwrdn_o dphy_reset_n_i dphy_reset_n_o en_clk_dphy_i en_clk_dphy_o en_iso_vddphy_i
+ hs_ser_msb_first_en_i hs_ser_msb_first_en_o hstx_en_fast_trf_i hstx_en_fast_trf_o hstx_lower_imp_cal_i<2> hstx_lower_imp_cal_i<1> hstx_lower_imp_cal_i<0> hstx_lower_imp_cal_o<2> hstx_lower_imp_cal_o<1> hstx_lower_imp_cal_o<0> hstx_upper_imp_cal_i<2>
+ hstx_upper_imp_cal_i<1> hstx_upper_imp_cal_i<0> hstx_upper_imp_cal_o<2> hstx_upper_imp_cal_o<1> hstx_upper_imp_cal_o<0> lptx_vref_prog_i<4> lptx_vref_prog_i<3> lptx_vref_prog_i<2> lptx_vref_prog_i<1> lptx_vref_prog_i<0> lptx_vref_prog_o<4> lptx_vref_prog_o<3>
+ lptx_vref_prog_o<2> lptx_vref_prog_o<1> lptx_vref_prog_o<0> n_mux_iq_sel_i n_mux_iq_sel_o sel_dr_i sel_dr_o inh_bulk_n inh_bulk_p
  XIsparedig<3> net0188<3> inh_bulk_n inh_bulk_p VDDD1V5 GNDD TIEZERO
  XIsparedig<2> net0188<2> inh_bulk_n inh_bulk_p VDDD1V5 GNDD TIEZERO
  XIsparedig<1> net0188<1> inh_bulk_n inh_bulk_p VDDD1V5 GNDD TIEZERO
  XIsparedig<0> net0188<0> inh_bulk_n inh_bulk_p VDDD1V5 GNDD TIEZERO
  XI116 net0192 inh_bulk_n inh_bulk_p VDDD1V5 GNDD TIEZERO
  XIsparetie<5> net0189<5> inh_bulk_n inh_bulk_p VDDPHY1V5 GNDPHY TIEZERO
  XIsparetie<4> net0189<4> inh_bulk_n inh_bulk_p VDDPHY1V5 GNDPHY TIEZERO
  XIsparetie<3> net0189<3> inh_bulk_n inh_bulk_p VDDPHY1V5 GNDPHY TIEZERO
  XIsparetie<2> net0189<2> inh_bulk_n inh_bulk_p VDDPHY1V5 GNDPHY TIEZERO
  XIsparetie<1> net0189<1> inh_bulk_n inh_bulk_p VDDPHY1V5 GNDPHY TIEZERO
  XIsparetie<0> net0189<0> inh_bulk_n inh_bulk_p VDDPHY1V5 GNDPHY TIEZERO
  XIsparegpin<5> VDDPHY1V5 GNDPHY net0193<5> net213 net0189<5> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XIsparegpin<4> VDDPHY1V5 GNDPHY net0193<4> net213 net0189<4> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XIsparegpin<3> VDDPHY1V5 GNDPHY net0193<3> net213 net0189<3> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XIsparegpin<2> VDDPHY1V5 GNDPHY net0193<2> net213 net0189<2> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XIsparegpin<1> VDDPHY1V5 GNDPHY net0193<1> net213 net0189<1> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XIsparegpin<0> VDDPHY1V5 GNDPHY net0193<0> net213 net0189<0> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI55<15> VDDD1V5 GNDD dl1_dft_hstx_data_lpbk_o<15> en_dig_s dl1_dft_hstx_data_lpbk_i<15> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI55<14> VDDD1V5 GNDD dl1_dft_hstx_data_lpbk_o<14> en_dig_s dl1_dft_hstx_data_lpbk_i<14> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI55<13> VDDD1V5 GNDD dl1_dft_hstx_data_lpbk_o<13> en_dig_s dl1_dft_hstx_data_lpbk_i<13> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI55<12> VDDD1V5 GNDD dl1_dft_hstx_data_lpbk_o<12> en_dig_s dl1_dft_hstx_data_lpbk_i<12> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI55<11> VDDD1V5 GNDD dl1_dft_hstx_data_lpbk_o<11> en_dig_s dl1_dft_hstx_data_lpbk_i<11> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI55<10> VDDD1V5 GNDD dl1_dft_hstx_data_lpbk_o<10> en_dig_s dl1_dft_hstx_data_lpbk_i<10> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI55<9> VDDD1V5 GNDD dl1_dft_hstx_data_lpbk_o<9> en_dig_s dl1_dft_hstx_data_lpbk_i<9> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI55<8> VDDD1V5 GNDD dl1_dft_hstx_data_lpbk_o<8> en_dig_s dl1_dft_hstx_data_lpbk_i<8> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI55<7> VDDD1V5 GNDD dl1_dft_hstx_data_lpbk_o<7> en_dig_s dl1_dft_hstx_data_lpbk_i<7> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI55<6> VDDD1V5 GNDD dl1_dft_hstx_data_lpbk_o<6> en_dig_s dl1_dft_hstx_data_lpbk_i<6> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI55<5> VDDD1V5 GNDD dl1_dft_hstx_data_lpbk_o<5> en_dig_s dl1_dft_hstx_data_lpbk_i<5> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI55<4> VDDD1V5 GNDD dl1_dft_hstx_data_lpbk_o<4> en_dig_s dl1_dft_hstx_data_lpbk_i<4> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI55<3> VDDD1V5 GNDD dl1_dft_hstx_data_lpbk_o<3> en_dig_s dl1_dft_hstx_data_lpbk_i<3> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI55<2> VDDD1V5 GNDD dl1_dft_hstx_data_lpbk_o<2> en_dig_s dl1_dft_hstx_data_lpbk_i<2> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI55<1> VDDD1V5 GNDD dl1_dft_hstx_data_lpbk_o<1> en_dig_s dl1_dft_hstx_data_lpbk_i<1> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI55<0> VDDD1V5 GNDD dl1_dft_hstx_data_lpbk_o<0> en_dig_s dl1_dft_hstx_data_lpbk_i<0> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI54<15> VDDD1V5 GNDD cl_dft_hstx_data_lpbk_o<15> en_dig_s cl_dft_hstx_data_lpbk_i<15> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI54<14> VDDD1V5 GNDD cl_dft_hstx_data_lpbk_o<14> en_dig_s cl_dft_hstx_data_lpbk_i<14> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI54<13> VDDD1V5 GNDD cl_dft_hstx_data_lpbk_o<13> en_dig_s cl_dft_hstx_data_lpbk_i<13> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI54<12> VDDD1V5 GNDD cl_dft_hstx_data_lpbk_o<12> en_dig_s cl_dft_hstx_data_lpbk_i<12> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI54<11> VDDD1V5 GNDD cl_dft_hstx_data_lpbk_o<11> en_dig_s cl_dft_hstx_data_lpbk_i<11> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI54<10> VDDD1V5 GNDD cl_dft_hstx_data_lpbk_o<10> en_dig_s cl_dft_hstx_data_lpbk_i<10> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI54<9> VDDD1V5 GNDD cl_dft_hstx_data_lpbk_o<9> en_dig_s cl_dft_hstx_data_lpbk_i<9> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI54<8> VDDD1V5 GNDD cl_dft_hstx_data_lpbk_o<8> en_dig_s cl_dft_hstx_data_lpbk_i<8> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI54<7> VDDD1V5 GNDD cl_dft_hstx_data_lpbk_o<7> en_dig_s cl_dft_hstx_data_lpbk_i<7> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI54<6> VDDD1V5 GNDD cl_dft_hstx_data_lpbk_o<6> en_dig_s cl_dft_hstx_data_lpbk_i<6> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI54<5> VDDD1V5 GNDD cl_dft_hstx_data_lpbk_o<5> en_dig_s cl_dft_hstx_data_lpbk_i<5> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI54<4> VDDD1V5 GNDD cl_dft_hstx_data_lpbk_o<4> en_dig_s cl_dft_hstx_data_lpbk_i<4> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI54<3> VDDD1V5 GNDD cl_dft_hstx_data_lpbk_o<3> en_dig_s cl_dft_hstx_data_lpbk_i<3> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI54<2> VDDD1V5 GNDD cl_dft_hstx_data_lpbk_o<2> en_dig_s cl_dft_hstx_data_lpbk_i<2> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI54<1> VDDD1V5 GNDD cl_dft_hstx_data_lpbk_o<1> en_dig_s cl_dft_hstx_data_lpbk_i<1> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI54<0> VDDD1V5 GNDD cl_dft_hstx_data_lpbk_o<0> en_dig_s cl_dft_hstx_data_lpbk_i<0> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI45 VDDPHY1V5 GNDPHY dl0_lptx_en_o net213 dl0_lptx_en_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI43<2> VDDPHY1V5 GNDPHY dl0_delay_prog_o<2> net213 dl0_delay_prog_i<2> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI43<1> VDDPHY1V5 GNDPHY dl0_delay_prog_o<1> net213 dl0_delay_prog_i<1> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI43<0> VDDPHY1V5 GNDPHY dl0_delay_prog_o<0> net213 dl0_delay_prog_i<0> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI36 VDDPHY1V5 GNDPHY dl0_dft_hstx_lower_path_en_o net213 dl0_dft_hstx_lower_path_en_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI100<15> VDDPHY1V5 GNDPHY dl2_hstx_data_o<15> net213 dl2_hstx_data_i<15> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI100<14> VDDPHY1V5 GNDPHY dl2_hstx_data_o<14> net213 dl2_hstx_data_i<14> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI100<13> VDDPHY1V5 GNDPHY dl2_hstx_data_o<13> net213 dl2_hstx_data_i<13> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI100<12> VDDPHY1V5 GNDPHY dl2_hstx_data_o<12> net213 dl2_hstx_data_i<12> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI100<11> VDDPHY1V5 GNDPHY dl2_hstx_data_o<11> net213 dl2_hstx_data_i<11> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI100<10> VDDPHY1V5 GNDPHY dl2_hstx_data_o<10> net213 dl2_hstx_data_i<10> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI100<9> VDDPHY1V5 GNDPHY dl2_hstx_data_o<9> net213 dl2_hstx_data_i<9> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI100<8> VDDPHY1V5 GNDPHY dl2_hstx_data_o<8> net213 dl2_hstx_data_i<8> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI100<7> VDDPHY1V5 GNDPHY dl2_hstx_data_o<7> net213 dl2_hstx_data_i<7> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI100<6> VDDPHY1V5 GNDPHY dl2_hstx_data_o<6> net213 dl2_hstx_data_i<6> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI100<5> VDDPHY1V5 GNDPHY dl2_hstx_data_o<5> net213 dl2_hstx_data_i<5> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI100<4> VDDPHY1V5 GNDPHY dl2_hstx_data_o<4> net213 dl2_hstx_data_i<4> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI100<3> VDDPHY1V5 GNDPHY dl2_hstx_data_o<3> net213 dl2_hstx_data_i<3> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI100<2> VDDPHY1V5 GNDPHY dl2_hstx_data_o<2> net213 dl2_hstx_data_i<2> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI100<1> VDDPHY1V5 GNDPHY dl2_hstx_data_o<1> net213 dl2_hstx_data_i<1> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI100<0> VDDPHY1V5 GNDPHY dl2_hstx_data_o<0> net213 dl2_hstx_data_i<0> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI32 VDDPHY1V5 GNDPHY dl0_lptx_dp_o net213 dl0_lptx_dp_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI31 VDDPHY1V5 GNDPHY dl0_lptx_dn_o net213 dl0_lptx_dn_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI16<2> VDDPHY1V5 GNDPHY dl3_delay_prog_o<2> net213 dl3_delay_prog_i<2> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI16<1> VDDPHY1V5 GNDPHY dl3_delay_prog_o<1> net213 dl3_delay_prog_i<1> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI16<0> VDDPHY1V5 GNDPHY dl3_delay_prog_o<0> net213 dl3_delay_prog_i<0> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI27 VDDPHY1V5 GNDPHY dl0_dft_deser_en_o net213 dl0_dft_deser_en_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI35 VDDPHY1V5 GNDPHY dl0_bypass_delay_line_o net213 dl0_bypass_delay_line_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI21 VDDPHY1V5 GNDPHY dl0_hs_ser_en_o net213 dl0_hs_ser_en_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI20 VDDPHY1V5 GNDPHY dl0_dft_ser_test_p_o net213 dl0_dft_ser_test_p_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI19 VDDPHY1V5 GNDPHY dl0_dft_ser_test_n_o net213 dl0_dft_ser_test_n_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI18 VDDPHY1V5 GNDPHY dl0_dft_ser_test_in_en_o net213 dl0_dft_ser_test_in_en_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI17 VDDPHY1V5 GNDPHY dl3_dft_hstx_lower_path_en_o net213 dl3_dft_hstx_lower_path_en_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI6<15> VDDPHY1V5 GNDPHY dl3_hstx_data_o<15> net213 dl3_hstx_data_i<15> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI6<14> VDDPHY1V5 GNDPHY dl3_hstx_data_o<14> net213 dl3_hstx_data_i<14> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI6<13> VDDPHY1V5 GNDPHY dl3_hstx_data_o<13> net213 dl3_hstx_data_i<13> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI6<12> VDDPHY1V5 GNDPHY dl3_hstx_data_o<12> net213 dl3_hstx_data_i<12> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI6<11> VDDPHY1V5 GNDPHY dl3_hstx_data_o<11> net213 dl3_hstx_data_i<11> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI6<10> VDDPHY1V5 GNDPHY dl3_hstx_data_o<10> net213 dl3_hstx_data_i<10> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI6<9> VDDPHY1V5 GNDPHY dl3_hstx_data_o<9> net213 dl3_hstx_data_i<9> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI6<8> VDDPHY1V5 GNDPHY dl3_hstx_data_o<8> net213 dl3_hstx_data_i<8> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI6<7> VDDPHY1V5 GNDPHY dl3_hstx_data_o<7> net213 dl3_hstx_data_i<7> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI6<6> VDDPHY1V5 GNDPHY dl3_hstx_data_o<6> net213 dl3_hstx_data_i<6> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI6<5> VDDPHY1V5 GNDPHY dl3_hstx_data_o<5> net213 dl3_hstx_data_i<5> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI6<4> VDDPHY1V5 GNDPHY dl3_hstx_data_o<4> net213 dl3_hstx_data_i<4> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI6<3> VDDPHY1V5 GNDPHY dl3_hstx_data_o<3> net213 dl3_hstx_data_i<3> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI6<2> VDDPHY1V5 GNDPHY dl3_hstx_data_o<2> net213 dl3_hstx_data_i<2> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI6<1> VDDPHY1V5 GNDPHY dl3_hstx_data_o<1> net213 dl3_hstx_data_i<1> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI6<0> VDDPHY1V5 GNDPHY dl3_hstx_data_o<0> net213 dl3_hstx_data_i<0> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI15 VDDPHY1V5 GNDPHY dl3_bypass_delay_line_o net213 dl3_bypass_delay_line_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI14 VDDPHY1V5 GNDPHY dl3_lptx_en_o net213 dl3_lptx_en_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI13 VDDPHY1V5 GNDPHY dl3_lptx_dp_o net213 dl3_lptx_dp_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI12 VDDPHY1V5 GNDPHY dl3_lptx_dn_o net213 dl3_lptx_dn_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI56 VDDPHY1V5 GNDPHY hstx_en_fast_trf_o net213 hstx_en_fast_trf_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI4 VDDPHY1V5 GNDPHY dl3_hs_ser_en_o net213 dl3_hs_ser_en_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI76<15> VDDPHY1V5 GNDPHY dl1_hstx_data_o<15> net213 dl1_hstx_data_i<15> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI76<14> VDDPHY1V5 GNDPHY dl1_hstx_data_o<14> net213 dl1_hstx_data_i<14> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI76<13> VDDPHY1V5 GNDPHY dl1_hstx_data_o<13> net213 dl1_hstx_data_i<13> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI76<12> VDDPHY1V5 GNDPHY dl1_hstx_data_o<12> net213 dl1_hstx_data_i<12> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI76<11> VDDPHY1V5 GNDPHY dl1_hstx_data_o<11> net213 dl1_hstx_data_i<11> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI76<10> VDDPHY1V5 GNDPHY dl1_hstx_data_o<10> net213 dl1_hstx_data_i<10> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI76<9> VDDPHY1V5 GNDPHY dl1_hstx_data_o<9> net213 dl1_hstx_data_i<9> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI76<8> VDDPHY1V5 GNDPHY dl1_hstx_data_o<8> net213 dl1_hstx_data_i<8> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI76<7> VDDPHY1V5 GNDPHY dl1_hstx_data_o<7> net213 dl1_hstx_data_i<7> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI76<6> VDDPHY1V5 GNDPHY dl1_hstx_data_o<6> net213 dl1_hstx_data_i<6> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI76<5> VDDPHY1V5 GNDPHY dl1_hstx_data_o<5> net213 dl1_hstx_data_i<5> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI76<4> VDDPHY1V5 GNDPHY dl1_hstx_data_o<4> net213 dl1_hstx_data_i<4> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI76<3> VDDPHY1V5 GNDPHY dl1_hstx_data_o<3> net213 dl1_hstx_data_i<3> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI76<2> VDDPHY1V5 GNDPHY dl1_hstx_data_o<2> net213 dl1_hstx_data_i<2> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI76<1> VDDPHY1V5 GNDPHY dl1_hstx_data_o<1> net213 dl1_hstx_data_i<1> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI76<0> VDDPHY1V5 GNDPHY dl1_hstx_data_o<0> net213 dl1_hstx_data_i<0> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI10 VDDPHY1V5 GNDPHY dl3_hstx_en_lptx_dis_o net213 dl3_hstx_en_lptx_dis_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI8 VDDPHY1V5 GNDPHY dl3_dft_deser_en_o net213 dl3_dft_deser_en_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI24<3> VDDPHY1V5 GNDPHY dft_ana_test_out_dphy_sel_o<3> net213 dft_ana_test_out_dphy_sel_i<3> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI24<2> VDDPHY1V5 GNDPHY dft_ana_test_out_dphy_sel_o<2> net213 dft_ana_test_out_dphy_sel_i<2> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI24<1> VDDPHY1V5 GNDPHY dft_ana_test_out_dphy_sel_o<1> net213 dft_ana_test_out_dphy_sel_i<1> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI24<0> VDDPHY1V5 GNDPHY dft_ana_test_out_dphy_sel_o<0> net213 dft_ana_test_out_dphy_sel_i<0> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI153 VDDD1V5 GNDD dl1_tx_byte_clk_o en_dig_s dl1_tx_byte_clk_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI52<15> VDDD1V5 GNDD dl0_dft_hstx_data_lpbk_o<15> en_dig_s dl0_dft_hstx_data_lpbk_i<15> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI52<14> VDDD1V5 GNDD dl0_dft_hstx_data_lpbk_o<14> en_dig_s dl0_dft_hstx_data_lpbk_i<14> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI52<13> VDDD1V5 GNDD dl0_dft_hstx_data_lpbk_o<13> en_dig_s dl0_dft_hstx_data_lpbk_i<13> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI52<12> VDDD1V5 GNDD dl0_dft_hstx_data_lpbk_o<12> en_dig_s dl0_dft_hstx_data_lpbk_i<12> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI52<11> VDDD1V5 GNDD dl0_dft_hstx_data_lpbk_o<11> en_dig_s dl0_dft_hstx_data_lpbk_i<11> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI52<10> VDDD1V5 GNDD dl0_dft_hstx_data_lpbk_o<10> en_dig_s dl0_dft_hstx_data_lpbk_i<10> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI52<9> VDDD1V5 GNDD dl0_dft_hstx_data_lpbk_o<9> en_dig_s dl0_dft_hstx_data_lpbk_i<9> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI52<8> VDDD1V5 GNDD dl0_dft_hstx_data_lpbk_o<8> en_dig_s dl0_dft_hstx_data_lpbk_i<8> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI52<7> VDDD1V5 GNDD dl0_dft_hstx_data_lpbk_o<7> en_dig_s dl0_dft_hstx_data_lpbk_i<7> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI52<6> VDDD1V5 GNDD dl0_dft_hstx_data_lpbk_o<6> en_dig_s dl0_dft_hstx_data_lpbk_i<6> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI52<5> VDDD1V5 GNDD dl0_dft_hstx_data_lpbk_o<5> en_dig_s dl0_dft_hstx_data_lpbk_i<5> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI52<4> VDDD1V5 GNDD dl0_dft_hstx_data_lpbk_o<4> en_dig_s dl0_dft_hstx_data_lpbk_i<4> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI52<3> VDDD1V5 GNDD dl0_dft_hstx_data_lpbk_o<3> en_dig_s dl0_dft_hstx_data_lpbk_i<3> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI52<2> VDDD1V5 GNDD dl0_dft_hstx_data_lpbk_o<2> en_dig_s dl0_dft_hstx_data_lpbk_i<2> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI52<1> VDDD1V5 GNDD dl0_dft_hstx_data_lpbk_o<1> en_dig_s dl0_dft_hstx_data_lpbk_i<1> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI52<0> VDDD1V5 GNDD dl0_dft_hstx_data_lpbk_o<0> en_dig_s dl0_dft_hstx_data_lpbk_i<0> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI53<15> VDDD1V5 GNDD dl2_dft_hstx_data_lpbk_o<15> en_dig_s dl2_dft_hstx_data_lpbk_i<15> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI53<14> VDDD1V5 GNDD dl2_dft_hstx_data_lpbk_o<14> en_dig_s dl2_dft_hstx_data_lpbk_i<14> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI53<13> VDDD1V5 GNDD dl2_dft_hstx_data_lpbk_o<13> en_dig_s dl2_dft_hstx_data_lpbk_i<13> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI53<12> VDDD1V5 GNDD dl2_dft_hstx_data_lpbk_o<12> en_dig_s dl2_dft_hstx_data_lpbk_i<12> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI53<11> VDDD1V5 GNDD dl2_dft_hstx_data_lpbk_o<11> en_dig_s dl2_dft_hstx_data_lpbk_i<11> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI53<10> VDDD1V5 GNDD dl2_dft_hstx_data_lpbk_o<10> en_dig_s dl2_dft_hstx_data_lpbk_i<10> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI53<9> VDDD1V5 GNDD dl2_dft_hstx_data_lpbk_o<9> en_dig_s dl2_dft_hstx_data_lpbk_i<9> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI53<8> VDDD1V5 GNDD dl2_dft_hstx_data_lpbk_o<8> en_dig_s dl2_dft_hstx_data_lpbk_i<8> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI53<7> VDDD1V5 GNDD dl2_dft_hstx_data_lpbk_o<7> en_dig_s dl2_dft_hstx_data_lpbk_i<7> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI53<6> VDDD1V5 GNDD dl2_dft_hstx_data_lpbk_o<6> en_dig_s dl2_dft_hstx_data_lpbk_i<6> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI53<5> VDDD1V5 GNDD dl2_dft_hstx_data_lpbk_o<5> en_dig_s dl2_dft_hstx_data_lpbk_i<5> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI53<4> VDDD1V5 GNDD dl2_dft_hstx_data_lpbk_o<4> en_dig_s dl2_dft_hstx_data_lpbk_i<4> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI53<3> VDDD1V5 GNDD dl2_dft_hstx_data_lpbk_o<3> en_dig_s dl2_dft_hstx_data_lpbk_i<3> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI53<2> VDDD1V5 GNDD dl2_dft_hstx_data_lpbk_o<2> en_dig_s dl2_dft_hstx_data_lpbk_i<2> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI53<1> VDDD1V5 GNDD dl2_dft_hstx_data_lpbk_o<1> en_dig_s dl2_dft_hstx_data_lpbk_i<1> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI53<0> VDDD1V5 GNDD dl2_dft_hstx_data_lpbk_o<0> en_dig_s dl2_dft_hstx_data_lpbk_i<0> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI23<15> VDDPHY1V5 GNDPHY dl0_hstx_data_o<15> net213 dl0_hstx_data_i<15> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI23<14> VDDPHY1V5 GNDPHY dl0_hstx_data_o<14> net213 dl0_hstx_data_i<14> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI23<13> VDDPHY1V5 GNDPHY dl0_hstx_data_o<13> net213 dl0_hstx_data_i<13> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI23<12> VDDPHY1V5 GNDPHY dl0_hstx_data_o<12> net213 dl0_hstx_data_i<12> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI23<11> VDDPHY1V5 GNDPHY dl0_hstx_data_o<11> net213 dl0_hstx_data_i<11> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI23<10> VDDPHY1V5 GNDPHY dl0_hstx_data_o<10> net213 dl0_hstx_data_i<10> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI23<9> VDDPHY1V5 GNDPHY dl0_hstx_data_o<9> net213 dl0_hstx_data_i<9> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI23<8> VDDPHY1V5 GNDPHY dl0_hstx_data_o<8> net213 dl0_hstx_data_i<8> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI23<7> VDDPHY1V5 GNDPHY dl0_hstx_data_o<7> net213 dl0_hstx_data_i<7> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI23<6> VDDPHY1V5 GNDPHY dl0_hstx_data_o<6> net213 dl0_hstx_data_i<6> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI23<5> VDDPHY1V5 GNDPHY dl0_hstx_data_o<5> net213 dl0_hstx_data_i<5> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI23<4> VDDPHY1V5 GNDPHY dl0_hstx_data_o<4> net213 dl0_hstx_data_i<4> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI23<3> VDDPHY1V5 GNDPHY dl0_hstx_data_o<3> net213 dl0_hstx_data_i<3> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI23<2> VDDPHY1V5 GNDPHY dl0_hstx_data_o<2> net213 dl0_hstx_data_i<2> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI23<1> VDDPHY1V5 GNDPHY dl0_hstx_data_o<1> net213 dl0_hstx_data_i<1> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI23<0> VDDPHY1V5 GNDPHY dl0_hstx_data_o<0> net213 dl0_hstx_data_i<0> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI51 VDDPHY1V5 GNDPHY sel_dr_o net213 sel_dr_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI1 VDDPHY1V5 GNDPHY dl3_dft_ser_test_in_en_o net213 dl3_dft_ser_test_in_en_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI374 VDDPHY1V5 GNDPHY n_mux_iq_sel_o net213 n_mux_iq_sel_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI92 VDDPHY1V5 GNDPHY cl_dft_ser_test_p_o net213 cl_dft_ser_test_p_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI93 VDDPHY1V5 GNDPHY dl1_dft_ser_test_p_o net213 dl1_dft_ser_test_p_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI159 VDDPHY1V5 GNDPHY dft_pll_clks_2_cl_en_o net213 dft_pll_clks_2_cl_en_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI42 VDDPHY1V5 GNDPHY dl2_bypass_delay_line_o net213 dl2_bypass_delay_line_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI41 VDDPHY1V5 GNDPHY dl2_dft_deser_en_o net213 dl2_dft_deser_en_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI95 VDDPHY1V5 GNDPHY dl2_lptx_dn_o net213 dl2_lptx_dn_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI96 VDDPHY1V5 GNDPHY dl2_dft_ser_test_in_en_o net213 dl2_dft_ser_test_in_en_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI98 VDDPHY1V5 GNDPHY dl2_dft_ser_test_n_o net213 dl2_dft_ser_test_n_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI97 VDDPHY1V5 GNDPHY dl2_dft_ser_test_p_o net213 dl2_dft_ser_test_p_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI99<2> VDDPHY1V5 GNDPHY dl2_delay_prog_o<2> net213 dl2_delay_prog_i<2> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI99<1> VDDPHY1V5 GNDPHY dl2_delay_prog_o<1> net213 dl2_delay_prog_i<1> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI99<0> VDDPHY1V5 GNDPHY dl2_delay_prog_o<0> net213 dl2_delay_prog_i<0> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI253 VDDPHY1V5 GNDPHY en_clk_dphy_o net213 en_clk_dphy_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI242 VDDPHY1V5 GNDPHY dl2_dft_hstx_lower_path_en_o net213 dl2_dft_hstx_lower_path_en_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI50<15> VDDPHY1V5 GNDPHY cl_hstx_data_o<15> net213 cl_hstx_data_i<15> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI50<14> VDDPHY1V5 GNDPHY cl_hstx_data_o<14> net213 cl_hstx_data_i<14> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI50<13> VDDPHY1V5 GNDPHY cl_hstx_data_o<13> net213 cl_hstx_data_i<13> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI50<12> VDDPHY1V5 GNDPHY cl_hstx_data_o<12> net213 cl_hstx_data_i<12> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI50<11> VDDPHY1V5 GNDPHY cl_hstx_data_o<11> net213 cl_hstx_data_i<11> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI50<10> VDDPHY1V5 GNDPHY cl_hstx_data_o<10> net213 cl_hstx_data_i<10> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI50<9> VDDPHY1V5 GNDPHY cl_hstx_data_o<9> net213 cl_hstx_data_i<9> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI50<8> VDDPHY1V5 GNDPHY cl_hstx_data_o<8> net213 cl_hstx_data_i<8> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI50<7> VDDPHY1V5 GNDPHY cl_hstx_data_o<7> net213 cl_hstx_data_i<7> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI50<6> VDDPHY1V5 GNDPHY cl_hstx_data_o<6> net213 cl_hstx_data_i<6> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI50<5> VDDPHY1V5 GNDPHY cl_hstx_data_o<5> net213 cl_hstx_data_i<5> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI50<4> VDDPHY1V5 GNDPHY cl_hstx_data_o<4> net213 cl_hstx_data_i<4> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI50<3> VDDPHY1V5 GNDPHY cl_hstx_data_o<3> net213 cl_hstx_data_i<3> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI50<2> VDDPHY1V5 GNDPHY cl_hstx_data_o<2> net213 cl_hstx_data_i<2> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI50<1> VDDPHY1V5 GNDPHY cl_hstx_data_o<1> net213 cl_hstx_data_i<1> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI50<0> VDDPHY1V5 GNDPHY cl_hstx_data_o<0> net213 cl_hstx_data_i<0> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI101 VDDPHY1V5 GNDPHY dl2_hs_ser_en_o net213 dl2_hs_ser_en_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XIsparegpind<3> VDDD1V5 GNDD net0190<3> en_dig_s net0188<3> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XIsparegpind<2> VDDD1V5 GNDD net0190<2> en_dig_s net0188<2> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XIsparegpind<1> VDDD1V5 GNDD net0190<1> en_dig_s net0188<1> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XIsparegpind<0> VDDD1V5 GNDD net0190<0> en_dig_s net0188<0> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI105 VDDPHY1V5 GNDPHY dl2_hstx_en_lptx_dis_o net213 dl2_hstx_en_lptx_dis_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI106 VDDPHY1V5 GNDPHY dl2_lptx_en_o net213 dl2_lptx_en_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI107 VDDPHY1V5 GNDPHY dl2_lptx_dp_o net213 dl2_lptx_dp_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI82 VDDPHY1V5 GNDPHY cl_lptx_dp_o net213 cl_lptx_dp_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI83 VDDPHY1V5 GNDPHY cl_lptx_en_o net213 cl_lptx_en_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI84 VDDPHY1V5 GNDPHY cl_hstx_en_lptx_dis_o net213 cl_hstx_en_lptx_dis_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI86 VDDPHY1V5 GNDPHY cl_hs_ser_en_o net213 cl_hs_ser_en_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI29 VDDPHY1V5 GNDPHY dl0_hstx_en_lptx_dis_o net213 dl0_hstx_en_lptx_dis_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI243 VDDPHY1V5 GNDPHY cl_dft_hstx_lower_path_en_o net213 cl_dft_hstx_lower_path_en_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI3 VDDPHY1V5 GNDPHY dl3_dft_ser_test_p_o net213 dl3_dft_ser_test_p_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI94<2> VDDPHY1V5 GNDPHY cl_delay_prog_o<2> net213 cl_delay_prog_i<2> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI94<1> VDDPHY1V5 GNDPHY cl_delay_prog_o<1> net213 cl_delay_prog_i<1> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI94<0> VDDPHY1V5 GNDPHY cl_delay_prog_o<0> net213 cl_delay_prog_i<0> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI193 VDDPHY1V5 GNDPHY cl_dft_ser_test_n_o net213 cl_dft_ser_test_n_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI91 VDDPHY1V5 GNDPHY cl_dft_ser_test_in_en_o net213 cl_dft_ser_test_in_en_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI90 VDDPHY1V5 GNDPHY cl_lptx_dn_o net213 cl_lptx_dn_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI40 VDDPHY1V5 GNDPHY cl_dft_deser_en_o net213 cl_dft_deser_en_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI39 VDDPHY1V5 GNDPHY cl_bypass_delay_line_o net213 cl_bypass_delay_line_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI37 VDDPHY1V5 GNDPHY dl1_dft_deser_en_o net213 dl1_dft_deser_en_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI38 VDDPHY1V5 GNDPHY dl1_bypass_delay_line_o net213 dl1_bypass_delay_line_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI78 VDDPHY1V5 GNDPHY dl1_dft_ser_test_n_o net213 dl1_dft_ser_test_n_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI80 VDDPHY1V5 GNDPHY dl1_dft_ser_test_in_en_o net213 dl1_dft_ser_test_in_en_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI81 VDDPHY1V5 GNDPHY dl1_lptx_dn_o net213 dl1_lptx_dn_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI376 VDDPHY1V5 GNDPHY dft_dphy_ocdldo_res_dis_o net213 dft_dphy_ocdldo_res_dis_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI110<4> VDDPHY1V5 GNDPHY lptx_vref_prog_o<4> net213 lptx_vref_prog_i<4> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI110<3> VDDPHY1V5 GNDPHY lptx_vref_prog_o<3> net213 lptx_vref_prog_i<3> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI110<2> VDDPHY1V5 GNDPHY lptx_vref_prog_o<2> net213 lptx_vref_prog_i<2> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI110<1> VDDPHY1V5 GNDPHY lptx_vref_prog_o<1> net213 lptx_vref_prog_i<1> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI110<0> VDDPHY1V5 GNDPHY lptx_vref_prog_o<0> net213 lptx_vref_prog_i<0> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI373 VDDPHY1V5 GNDPHY dphy_reset_n_s net213 dphy_reset_n_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI77<2> VDDPHY1V5 GNDPHY dl1_delay_prog_o<2> net213 dl1_delay_prog_i<2> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI77<1> VDDPHY1V5 GNDPHY dl1_delay_prog_o<1> net213 dl1_delay_prog_i<1> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI77<0> VDDPHY1V5 GNDPHY dl1_delay_prog_o<0> net213 dl1_delay_prog_i<0> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI69 VDDPHY1V5 GNDPHY dl1_lptx_dp_o net213 dl1_lptx_dp_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI217 VDDPHY1V5 GNDPHY dl1_lptx_en_o net213 dl1_lptx_en_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI71 VDDPHY1V5 GNDPHY dl1_hstx_en_lptx_dis_o net213 dl1_hstx_en_lptx_dis_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI75 VDDPHY1V5 GNDPHY dl1_hs_ser_en_o net213 dl1_hs_ser_en_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI160 VDDPHY1V5 GNDPHY hs_ser_msb_first_en_o net213 hs_ser_msb_first_en_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI46<15> VDDD1V5 GNDD dl3_dft_hstx_data_lpbk_o<15> en_dig_s dl3_dft_hstx_data_lpbk_i<15> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI46<14> VDDD1V5 GNDD dl3_dft_hstx_data_lpbk_o<14> en_dig_s dl3_dft_hstx_data_lpbk_i<14> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI46<13> VDDD1V5 GNDD dl3_dft_hstx_data_lpbk_o<13> en_dig_s dl3_dft_hstx_data_lpbk_i<13> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI46<12> VDDD1V5 GNDD dl3_dft_hstx_data_lpbk_o<12> en_dig_s dl3_dft_hstx_data_lpbk_i<12> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI46<11> VDDD1V5 GNDD dl3_dft_hstx_data_lpbk_o<11> en_dig_s dl3_dft_hstx_data_lpbk_i<11> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI46<10> VDDD1V5 GNDD dl3_dft_hstx_data_lpbk_o<10> en_dig_s dl3_dft_hstx_data_lpbk_i<10> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI46<9> VDDD1V5 GNDD dl3_dft_hstx_data_lpbk_o<9> en_dig_s dl3_dft_hstx_data_lpbk_i<9> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI46<8> VDDD1V5 GNDD dl3_dft_hstx_data_lpbk_o<8> en_dig_s dl3_dft_hstx_data_lpbk_i<8> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI46<7> VDDD1V5 GNDD dl3_dft_hstx_data_lpbk_o<7> en_dig_s dl3_dft_hstx_data_lpbk_i<7> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI46<6> VDDD1V5 GNDD dl3_dft_hstx_data_lpbk_o<6> en_dig_s dl3_dft_hstx_data_lpbk_i<6> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI46<5> VDDD1V5 GNDD dl3_dft_hstx_data_lpbk_o<5> en_dig_s dl3_dft_hstx_data_lpbk_i<5> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI46<4> VDDD1V5 GNDD dl3_dft_hstx_data_lpbk_o<4> en_dig_s dl3_dft_hstx_data_lpbk_i<4> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI46<3> VDDD1V5 GNDD dl3_dft_hstx_data_lpbk_o<3> en_dig_s dl3_dft_hstx_data_lpbk_i<3> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI46<2> VDDD1V5 GNDD dl3_dft_hstx_data_lpbk_o<2> en_dig_s dl3_dft_hstx_data_lpbk_i<2> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI46<1> VDDD1V5 GNDD dl3_dft_hstx_data_lpbk_o<1> en_dig_s dl3_dft_hstx_data_lpbk_i<1> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI46<0> VDDD1V5 GNDD dl3_dft_hstx_data_lpbk_o<0> en_dig_s dl3_dft_hstx_data_lpbk_i<0> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI241 VDDPHY1V5 GNDPHY dl1_dft_hstx_lower_path_en_o net213 dl1_dft_hstx_lower_path_en_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI68<2> VDDPHY1V5 GNDPHY hstx_lower_imp_cal_o<2> net213 hstx_lower_imp_cal_i<2> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI68<1> VDDPHY1V5 GNDPHY hstx_lower_imp_cal_o<1> net213 hstx_lower_imp_cal_i<1> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI68<0> VDDPHY1V5 GNDPHY hstx_lower_imp_cal_o<0> net213 hstx_lower_imp_cal_i<0> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI44<2> VDDPHY1V5 GNDPHY hstx_upper_imp_cal_o<2> net213 hstx_upper_imp_cal_i<2> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI44<1> VDDPHY1V5 GNDPHY hstx_upper_imp_cal_o<1> net213 hstx_upper_imp_cal_i<1> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI44<0> VDDPHY1V5 GNDPHY hstx_upper_imp_cal_o<0> net213 hstx_upper_imp_cal_i<0> inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI2 VDDPHY1V5 GNDPHY dl3_dft_ser_test_n_o net213 dl3_dft_ser_test_n_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI25 VDDPHY1V5 GNDPHY dft_ana_test_en_o net213 dft_ana_test_en_i inh_bulk_n inh_bulk_p phy_mipi_gpin_en
  XI48 VDDPHY1V5 GNDPHY dl3_hstx_pwrdn_o net213 dl3_hstx_pwrdn_i inh_bulk_n inh_bulk_p phy_mipi_gpin_pd
  XI49 VDDPHY1V5 GNDPHY dl0_hstx_pwrdn_o net213 dl0_hstx_pwrdn_i inh_bulk_n inh_bulk_p phy_mipi_gpin_pd
  XI104 VDDPHY1V5 GNDPHY dl2_hstx_pwrdn_o net213 dl2_hstx_pwrdn_i inh_bulk_n inh_bulk_p phy_mipi_gpin_pd
  XI85 VDDPHY1V5 GNDPHY cl_hstx_pwrdn_o net213 cl_hstx_pwrdn_i inh_bulk_n inh_bulk_p phy_mipi_gpin_pd
  XI72 VDDPHY1V5 GNDPHY dl1_hstx_pwrdn_o net213 dl1_hstx_pwrdn_i inh_bulk_n inh_bulk_p phy_mipi_gpin_pd
  XI64 VDDPHY1V5 GNDPHY dphy_pwrdn_o net213 dphy_pwrdn_i inh_bulk_n inh_bulk_p phy_mipi_gpin_pd
  XI317 dphy_pwrdn_i en_dig_s inh_bulk_n inh_bulk_p VDDD1V5 GNDD INV24
  XI117 dphy_reset_n_s dphy_reset_n_o inh_bulk_n inh_bulk_p VDDPHY1V5 GNDPHY BUF24
  XI252 en_iso_vddphy_i net213 inh_bulk_n inh_bulk_p VDDPHY1V5 GNDPHY BUF24
  C0 net0192 GNDD C='1f'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: MX2B
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT MX2B A0 A1 S Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  MP0 net101 A0 inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  MP3 net62 net79 net59 inh_bulk_p PREG W='1.12u' L='120.0n' M='1'
  MP2 net62 S net101 inh_bulk_p PREG W='1.12u' L='120.0n' M='1'
  Mptrans74 net79 S inh_hSup inh_bulk_p PREG W='1.2u' L='120.0n' M='1'
  MP1 net59 A1 inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  Mptrans68 Z net62 inh_hSup inh_bulk_p PREG W='3.24u' L='120.0n' M='1'
  Mntrans73 net79 S inh_lSup inh_bulk_n NREG W='800n' L='120.0n' M='1'
  MN3 net62 S net59 inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  MN2 net62 net79 net101 inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  MN1 net59 A1 inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  MN0 net101 A0 inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  Mntrans70 Z net62 inh_lSup inh_bulk_n NREG W='2.24u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='9.9e-12'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_dft_mux
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_dft_mux A0 A1 A_Z B0 B1 B_Z S VDD VSS inh_bulk_n inh_bulk_p
  XI119 B0 B1 S B_Z inh_bulk_n inh_bulk_p VDD VSS MX2B
  XI118 A0 A1 S A_Z inh_bulk_n inh_bulk_p VDD VSS MX2B
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_bias_distributor_nmirr
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_bias_distributor_nmirr VSS d gc gm inh_bulk_n
  MN0<1> net06<1> gm VSS inh_bulk_n NANA W='2.5u' L='3u' M='1'
  MN0<0> net06<0> gm VSS inh_bulk_n NANA W='2.5u' L='3u' M='1'
  MN1<1> d gc net06<1> inh_bulk_n NANA W='2.5u' L='400n' M='1'
  MN1<0> d gc net06<0> inh_bulk_n NANA W='2.5u' L='400n' M='1'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_bias_distributor_nmirr_dy
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_bias_distributor_nmirr_dy VSS inh_bulk_n
  MN0<1> net06<1> VSS VSS inh_bulk_n NANA W='2.5u' L='3u' M='1'
  MN0<0> net06<0> VSS VSS inh_bulk_n NANA W='2.5u' L='3u' M='1'
  MN1<1> VSS VSS net06<1> inh_bulk_n NANA W='2.5u' L='400n' M='1'
  MN1<0> VSS VSS net06<0> inh_bulk_n NANA W='2.5u' L='400n' M='1'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_bias_distributor_nmirr_master
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_bias_distributor_nmirr_master VDD VSS gc gm ibias_40u_i ls_en_i pwd_i inh_bulk_n inh_bulk_p
  MP30 en_nmos_n_s en_nmos_s VDD inh_bulk_p PANA W='680.0n' L='400n' M='1'
  MP34 net31 pwd_i VDD inh_bulk_p PANA W='680.0n' L='400n' M='1'
  MP33 en_nmos_s net10 net31 inh_bulk_p PANA W='680.0n' L='400n' M='1'
  MP32 net10 ls_en_i VDD inh_bulk_p PANA W='680.0n' L='400n' M='1'
  XI14<3> VSS net37 gc gm inh_bulk_n phy_bias_distributor_nmirr
  XI14<2> VSS net37 gc gm inh_bulk_n phy_bias_distributor_nmirr
  XI14<1> VSS net37 gc gm inh_bulk_n phy_bias_distributor_nmirr
  XI14<0> VSS net37 gc gm inh_bulk_n phy_bias_distributor_nmirr
  XI3<1> VSS inh_bulk_n phy_bias_distributor_nmirr_dy
  XI3<0> VSS inh_bulk_n phy_bias_distributor_nmirr_dy
  MN4<5> VSS VSS VSS inh_bulk_n NANA W='2.5u' L='3u' M='1'
  MN4<4> VSS VSS VSS inh_bulk_n NANA W='2.5u' L='3u' M='1'
  MN4<3> VSS VSS VSS inh_bulk_n NANA W='2.5u' L='3u' M='1'
  MN4<2> VSS VSS VSS inh_bulk_n NANA W='2.5u' L='3u' M='1'
  MN4<1> VSS VSS VSS inh_bulk_n NANA W='2.5u' L='3u' M='1'
  MN4<0> VSS VSS VSS inh_bulk_n NANA W='2.5u' L='3u' M='1'
  MN10 gc en_nmos_n_s VSS inh_bulk_n NANA W='2.5u' L='400n' M='1'
  MN6 en_nmos_n_s en_nmos_s VSS inh_bulk_n NANA W='680.0n' L='400n' M='1'
  MN11 gm en_nmos_n_s VSS inh_bulk_n NANA W='2.5u' L='400n' M='1'
  MN9 gc en_nmos_s ibias_40u_i inh_bulk_n NANA W='10u' L='400n' M='1'
  MN8 gm en_nmos_s net37 inh_bulk_n NANA W='10u' L='400n' M='1'
  MN13 en_nmos_s net10 VSS inh_bulk_n NANA W='680.0n' L='400n' M='1'
  MN14 en_nmos_s pwd_i VSS inh_bulk_n NANA W='680.0n' L='400n' M='1'
  MN12 net10 ls_en_i VSS inh_bulk_n NANA W='680.0n' L='400n' M='1'
  rvcasc ibias_40u_i net37 R='3.998K'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_bias_distributor_pmirr_dy
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_bias_distributor_pmirr_dy VDD inh_bulk_p
  MP0<1> net06<1> VDD VDD inh_bulk_p PANA W='1.65u' L='2u' M='1'
  MP0<0> net06<0> VDD VDD inh_bulk_p PANA W='1.65u' L='2u' M='1'
  MP1<1> VDD VDD net06<1> inh_bulk_p PANA W='1.65u' L='400n' M='1'
  MP1<0> VDD VDD net06<0> inh_bulk_p PANA W='1.65u' L='400n' M='1'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_bias_distributor_pmirr
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_bias_distributor_pmirr VDD d gc gm inh_bulk_p
  MP0<1> net06<1> gm VDD inh_bulk_p PANA W='1.65u' L='2u' M='1'
  MP0<0> net06<0> gm VDD inh_bulk_p PANA W='1.65u' L='2u' M='1'
  MP1<1> d gc net06<1> inh_bulk_p PANA W='1.65u' L='400n' M='1'
  MP1<0> d gc net06<0> inh_bulk_p PANA W='1.65u' L='400n' M='1'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_bias_distributor
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_bias_distributor VDD VSS gc gm ibias1_10u_i ibias1_25u_o ibias2_10u_i ibias2_25u_o pwd_i inh_bulk_n inh_bulk_p
  XI27<1> VDD inh_bulk_p phy_bias_distributor_pmirr_dy
  XI27<0> VDD inh_bulk_p phy_bias_distributor_pmirr_dy
  MP1<1> net030<1> gc VDD inh_bulk_p PANA W='2.4u' L='2u' M='1'
  MP1<0> net030<0> gc VDD inh_bulk_p PANA W='2.4u' L='2u' M='1'
  MP4 net8 pwd_i VDD inh_bulk_p PANA W='680.0n' L='400n' M='1'
  MP7 gm net8 VDD inh_bulk_p PANA W='680.0n' L='400n' M='1'
  MP6 gc net8 VDD inh_bulk_p PANA W='680.0n' L='400n' M='1'
  MP3 gm net10 ibias2_10u_i inh_bulk_p PANA W='680.0n' L='400n' M='1'
  MP5 net10 net8 VDD inh_bulk_p PANA W='680.0n' L='400n' M='1'
  MP2 gc net10 ibias1_10u_i inh_bulk_p PANA W='680.0n' L='400n' M='1'
  MP0<1> ibias1_10u_i gc net030<1> inh_bulk_p PANA W='2.4u' L='2u' M='1'
  MP0<0> ibias1_10u_i gc net030<0> inh_bulk_p PANA W='2.4u' L='2u' M='1'
  MN2<13> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN2<12> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN2<11> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN2<10> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN2<9> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN2<8> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN2<7> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN2<6> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN2<5> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN2<4> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN2<3> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN2<2> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN2<1> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN2<0> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN3<1> VDD VDD VDD inh_bulk_n NANA W='2.4u' L='2u' M='1'
  MN3<0> VDD VDD VDD inh_bulk_n NANA W='2.4u' L='2u' M='1'
  MN5 net8 pwd_i VSS inh_bulk_n NANA W='680.0n' L='400n' M='1'
  MN1 gm net8 ibias2_10u_i inh_bulk_n NANA W='680.0n' L='400n' M='1'
  MN0 gc net8 ibias1_10u_i inh_bulk_n NANA W='680.0n' L='400n' M='1'
  MN4 net10 net8 VSS inh_bulk_n NANA W='680.0n' L='400n' M='1'
  XI16<4> VDD ibias2_25u_o gc gm inh_bulk_p phy_bias_distributor_pmirr
  XI16<3> VDD ibias2_25u_o gc gm inh_bulk_p phy_bias_distributor_pmirr
  XI16<2> VDD ibias2_25u_o gc gm inh_bulk_p phy_bias_distributor_pmirr
  XI16<1> VDD ibias2_25u_o gc gm inh_bulk_p phy_bias_distributor_pmirr
  XI16<0> VDD ibias2_25u_o gc gm inh_bulk_p phy_bias_distributor_pmirr
  XI15<4> VDD ibias1_25u_o gc gm inh_bulk_p phy_bias_distributor_pmirr
  XI15<3> VDD ibias1_25u_o gc gm inh_bulk_p phy_bias_distributor_pmirr
  XI15<2> VDD ibias1_25u_o gc gm inh_bulk_p phy_bias_distributor_pmirr
  XI15<1> VDD ibias1_25u_o gc gm inh_bulk_p phy_bias_distributor_pmirr
  XI15<0> VDD ibias1_25u_o gc gm inh_bulk_p phy_bias_distributor_pmirr
  XI17<1> VDD ibias2_10u_i gc gm inh_bulk_p phy_bias_distributor_pmirr
  XI17<0> VDD ibias2_10u_i gc gm inh_bulk_p phy_bias_distributor_pmirr
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_bias_distributor_top
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_bias_distributor_top VDD VSS ibias_25u_anamux_o ibias_25u_mon_o ibias_10u_o<9> ibias_10u_o<8> ibias_10u_o<7> ibias_10u_o<6> ibias_10u_o<5> ibias_10u_o<4> ibias_10u_o<3> ibias_10u_o<2> ibias_10u_o<1> ibias_10u_o<0> pwd_i ls_en_i ibias_40u_i inh_bulk_n
+ inh_bulk_p
  XI85 VDD VSS ncasc nmirr ibias_40u_i ls_en_i pwd_i inh_bulk_n inh_bulk_p phy_bias_distributor_nmirr_master
  Xbiasamux VDD VSS net063 net068 net045 ibias_25u_mon_o net062 ibias_25u_anamux_o pwd_i inh_bulk_n inh_bulk_p phy_bias_distributor
  XI86<1> VSS inh_bulk_n phy_bias_distributor_nmirr_dy
  XI86<0> VSS inh_bulk_n phy_bias_distributor_nmirr_dy
  XI31<9> net017 net019<9> ncasc nmirr inh_bulk_n phy_bias_distributor_nmirr
  XI31<8> net017 net019<8> ncasc nmirr inh_bulk_n phy_bias_distributor_nmirr
  XI31<7> net017 net019<7> ncasc nmirr inh_bulk_n phy_bias_distributor_nmirr
  XI31<6> net017 net019<6> ncasc nmirr inh_bulk_n phy_bias_distributor_nmirr
  XI31<5> net017 net019<5> ncasc nmirr inh_bulk_n phy_bias_distributor_nmirr
  XI31<4> net017 net019<4> ncasc nmirr inh_bulk_n phy_bias_distributor_nmirr
  XI31<3> net017 net019<3> ncasc nmirr inh_bulk_n phy_bias_distributor_nmirr
  XI31<2> net017 net019<2> ncasc nmirr inh_bulk_n phy_bias_distributor_nmirr
  XI31<1> net017 net019<1> ncasc nmirr inh_bulk_n phy_bias_distributor_nmirr
  XI31<0> net017 net019<0> ncasc nmirr inh_bulk_n phy_bias_distributor_nmirr
  XI12 VSS net050 ncasc nmirr inh_bulk_n phy_bias_distributor_nmirr
  XI13 VSS net31 ncasc nmirr inh_bulk_n phy_bias_distributor_nmirr
  Xc1<11> VSS ibias_40u_i VSS phy_ncap_200f
  Xc1<10> VSS ibias_40u_i VSS phy_ncap_200f
  Xc1<9> VSS ibias_40u_i VSS phy_ncap_200f
  Xc1<8> VSS ibias_40u_i VSS phy_ncap_200f
  Xc1<7> VSS ibias_40u_i VSS phy_ncap_200f
  Xc1<6> VSS ibias_40u_i VSS phy_ncap_200f
  Xc1<5> VSS ibias_40u_i VSS phy_ncap_200f
  Xc1<4> VSS ibias_40u_i VSS phy_ncap_200f
  Xc1<3> VSS ibias_40u_i VSS phy_ncap_200f
  Xc1<2> VSS ibias_40u_i VSS phy_ncap_200f
  Xc1<1> VSS ibias_40u_i VSS phy_ncap_200f
  Xc1<0> VSS ibias_40u_i VSS phy_ncap_200f
  VIMess26 net017 VSS DC 0
  VIMess25<9> ibias_10u_o<9> net019<9> DC 0
  VIMess25<8> ibias_10u_o<8> net019<8> DC 0
  VIMess25<7> ibias_10u_o<7> net019<7> DC 0
  VIMess25<6> ibias_10u_o<6> net019<6> DC 0
  VIMess25<5> ibias_10u_o<5> net019<5> DC 0
  VIMess25<4> ibias_10u_o<4> net019<4> DC 0
  VIMess25<3> ibias_10u_o<3> net019<3> DC 0
  VIMess25<2> ibias_10u_o<2> net019<2> DC 0
  VIMess25<1> ibias_10u_o<1> net019<1> DC 0
  VIMess25<0> ibias_10u_o<0> net019<0> DC 0
  VIMess8 net062 net050 DC 0
  VIMess0 net045 net31 DC 0
  MN4<13> VSS VSS VSS inh_bulk_n NANA W='2.5u' L='3u' M='1'
  MN4<12> VSS VSS VSS inh_bulk_n NANA W='2.5u' L='3u' M='1'
  MN4<11> VSS VSS VSS inh_bulk_n NANA W='2.5u' L='3u' M='1'
  MN4<10> VSS VSS VSS inh_bulk_n NANA W='2.5u' L='3u' M='1'
  MN4<9> VSS VSS VSS inh_bulk_n NANA W='2.5u' L='3u' M='1'
  MN4<8> VSS VSS VSS inh_bulk_n NANA W='2.5u' L='3u' M='1'
  MN4<7> VSS VSS VSS inh_bulk_n NANA W='2.5u' L='3u' M='1'
  MN4<6> VSS VSS VSS inh_bulk_n NANA W='2.5u' L='3u' M='1'
  MN4<5> VSS VSS VSS inh_bulk_n NANA W='2.5u' L='3u' M='1'
  MN4<4> VSS VSS VSS inh_bulk_n NANA W='2.5u' L='3u' M='1'
  MN4<3> VSS VSS VSS inh_bulk_n NANA W='2.5u' L='3u' M='1'
  MN4<2> VSS VSS VSS inh_bulk_n NANA W='2.5u' L='3u' M='1'
  MN4<1> VSS VSS VSS inh_bulk_n NANA W='2.5u' L='3u' M='1'
  MN4<0> VSS VSS VSS inh_bulk_n NANA W='2.5u' L='3u' M='1'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_supplybl_m2
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_supplybl_m2 VDD VSS inh_bulk_p
  MP2 VDD VSS VDD inh_bulk_p PANA W='2.52u' L='3.34u' M='1'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: OR2
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT OR2 A B Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mntrans27 net26 A inh_lSup inh_bulk_n NREG W='900n' L='120.0n' M='1'
  Mntrans26 net26 B inh_lSup inh_bulk_n NREG W='900n' L='120.0n' M='1'
  Mntrans25 Z net26 inh_lSup inh_bulk_n NREG W='600n' L='120.0n' M='1'
  Mptrans24 net26 A net41 inh_bulk_p PREG W='1.28u' L='120.0n' M='1'
  Mptrans23 net41 B inh_hSup inh_bulk_p PREG W='1.28u' L='120.0n' M='1'
  Mptrans22 Z net26 inh_hSup inh_bulk_p PREG W='860.0n' L='120.0n' M='1'
  XINSTANCE1 inh_hSup inh_lSup inh_bulk_n sub_diode
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_lptx_fc_ota_new
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_lptx_fc_ota_new VDD VSS comp ibias_25u_lptx_ota n_i o p_i pd_i inh_bulk_n inh_bulk_p
  MN10 net10 net19 net12 inh_bulk_n NREG W='2u' L='120.0n' M='1'
  MN6 x net12 VSS inh_bulk_n NREG W='7.52u' L='1.6u' M='1'
  MN7 net10 net14 x inh_bulk_n NREG W='2u' L='240.0n' M='1'
  MN5 net22 net14 net37 inh_bulk_n NREG W='2u' L='240.0n' M='1'
  MN3 o net14 comp inh_bulk_n NREG W='2u' L='240.0n' M='1'
  MN2 net30 net14 net34 inh_bulk_n NREG W='2u' L='240.0n' M='1'
  MN4 net37 net12 VSS inh_bulk_n NREG W='7.52u' L='1.6u' M='1'
  MN1 net34 net12 VSS inh_bulk_n NREG W='7.52u' L='1.6u' M='1'
  MN0 comp net12 VSS inh_bulk_n NREG W='7.52u' L='1.6u' M='1'
  MN11 ibias_25u_lptx_ota net19 net14 inh_bulk_n NREG W='2u' L='120.0n' M='1'
  MN9 net12 pd_i VSS inh_bulk_n NREG W='1u' L='120.0n' M='1'
  MN8 net14 pd_i VSS inh_bulk_n NREG W='1u' L='120.0n' M='1'
  R1 net38 net22 R='6.983K'
  R0 net20 net38 R='6.983K'
  R2 ibias_25u_lptx_ota net035 R='6.983K'
  R3 net035 net10 R='6.983K'
  MP0 net34 p_i source source PREG W='15.0u' L='500n' M='1'
  MP1 comp n_i source source PREG W='15.0u' L='500n' M='1'
  MP11 net30 net19 VDD inh_bulk_p PREG W='1u' L='120.0n' M='1'
  MP12 net22 net19 VDD inh_bulk_p PREG W='1u' L='120.0n' M='1'
  MP10 net20 net19 VDD inh_bulk_p PREG W='1u' L='120.0n' M='1'
  MP7<1> source net22 b inh_bulk_p PREG W='3u' L='120.0n' M='1'
  MP7<0> source net22 b inh_bulk_p PREG W='3u' L='120.0n' M='1'
  MP15<1> b net20 VDD inh_bulk_p PREG W='8.24u' L='500n' M='1'
  MP15<0> b net20 VDD inh_bulk_p PREG W='8.24u' L='500n' M='1'
  MP16 net35 net30 VDD inh_bulk_p PREG W='8.24u' L='500n' M='1'
  MP14 o net22 net35 inh_bulk_p PREG W='3u' L='120.0n' M='1'
  MP3 net36 net30 VDD inh_bulk_p PREG W='8.24u' L='500n' M='1'
  MP13 net30 net22 net36 inh_bulk_p PREG W='3u' L='120.0n' M='1'
  MP9<1> net20 net22 a inh_bulk_p PREG W='3u' L='120.0n' M='1'
  MP9<0> net20 net22 a inh_bulk_p PREG W='3u' L='120.0n' M='1'
  MP8<1> a net20 VDD inh_bulk_p PREG W='8.24u' L='500n' M='1'
  MP8<0> a net20 VDD inh_bulk_p PREG W='8.24u' L='500n' M='1'
  XI5 pd_i net19 inh_bulk_n inh_bulk_p VDD VSS INV4
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_lptx_ldo
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_lptx_ldo VDD VSS fb_i fb_o ibias_25u_lptx_ota ibias_25u_lptx_vref ldo_1v2 lptx_ldo_en_i monitor_en_i monitor_vout_o vref vref_prog_i<4> vref_prog_i<3> vref_prog_i<2> vref_prog_i<1> vref_prog_i<0> inh_bulk_n inh_bulk_p
  Msw_p2<1> monitor_vout_o net029 ldo_1v2 VDD PREG W='3.5u' L='120.0n' M='1'
  Msw_p2<0> monitor_vout_o net029 ldo_1v2 VDD PREG W='3.5u' L='120.0n' M='1'
  R31 net0132 net063 R='9.969K'
  R30 ref_R_2 net0128 R='502.5'
  R29 net0128 net0132 R='502.5'
  R1 net053 VSS R='3.006K'
  R33 net0100 ref_R_2 R='502.5'
  R0 net063 net053 R='9.969K'
  R34 ibias_25u_lptx_vref net0100 R='502.5'
  Rfb2 fb_o net048 R='1.963K'
  Rfb1 ldo_1v2 fb_o R='1.963K'
  MP1 pd_gate lptx_ldo_en_i VDD inh_bulk_p PREG W='2u' L='120.0n' M='1'
  MP0 VDD pd_gate ldo_1v2 inh_bulk_p PREG W='260.00000u' L='150.0n' M='1'
  MP8 fb_i pwd_s vfb_s inh_bulk_p PREG W='16.0u' L='120.0n' M='1'
  MP11 vfb_s lptx_ldo_en_i VDD inh_bulk_p PANA W='680.0n' L='1u' M='1'
  MP10 net029 monitor_en_i VDD inh_bulk_p PREG W='680.0n' L='120.0n' M='1'
  MP7 vref_s lptx_ldo_en_i VDD inh_bulk_p PANA W='680.0n' L='1u' M='1'
  MN5 net029 monitor_en_i VSS inh_bulk_n NREG W='680.0n' L='120.0n' M='1'
  MN4 monitor_vout_o net029 VSS inh_bulk_n NREG W='1u' L='120.0n' M='1'
  MN1 net048 lptx_ldo_en_i VSS inh_bulk_n NREG W='32.0u' L='120.0n' M='1'
  MN2 vref_s lptx_ldo_en_i ref_R_2_int inh_bulk_n NANA W='4u' L='1u' M='1'
  MN3 vfb_s lptx_ldo_en_i fb_i inh_bulk_n NREG W='8u' L='120.0n' M='1'
  MP6 ref_R_2_int vref_prog_i<4> ibias_25u_lptx_vref inh_bulk_n NANA W='4u' L='1u' M='1'
  MP5 ref_R_2_int vref_prog_i<3> net0100 inh_bulk_n NANA W='4u' L='1u' M='1'
  MP2 ref_R_2_int vref_prog_i<2> vref inh_bulk_n NANA W='4u' L='1u' M='1'
  MP4 ref_R_2_int vref_prog_i<0> net0128 inh_bulk_n NANA W='4u' L='1u' M='1'
  MP3 ref_R_2_int vref_prog_i<1> ref_R_2 inh_bulk_n NANA W='4u' L='1u' M='1'
  XI1 lptx_ldo_en_i pwd_s inh_bulk_n inh_bulk_p VDD VSS INV1
  C0 ldo_1v2 net044 C='201.2f' W='4.79u' L='7.19u'
  Xota VDD VSS net044 ibias_25u_lptx_ota vref_s pd_gate vfb_s pwd_s inh_bulk_n inh_bulk_p phy_lptx_fc_ota_new
  C1 ldo_1v2 VSS C='400f'
  Msw_n2 monitor_vout_o monitor_en_i ldo_1v2 VSS NREG W='3.5u' L='120.0n' M='1'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: INV10
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT INV10 A Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mptrans10 Z A inh_hSup inh_bulk_p PREG W='8.1u' L='120.0n' M='1'
  Mntrans11 Z A inh_lSup inh_bulk_n NREG W='5.6u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='7.2e-12'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: NOR2P
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT NOR2P A B Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mptrans17 Z A net27 inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  Mptrans16 net27 B inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  MP1 Z A net024 inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  MP0 net024 B inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  Mntrans19 Z A inh_lSup inh_bulk_n NREG W='2.24u' L='120.0n' M='1'
  Mntrans18 Z B inh_lSup inh_bulk_n NREG W='2.24u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='5.4e-12'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_lptx
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_lptx VDD VSS data_i en_i en_override_i ibias_10u_lptx ldo_1v2 pad inh_bulk_n inh_bulk_p
  XI5 data_i hstx_enable trans_p_p inh_bulk_n inh_bulk_p VDD VSS NAND2B
  XI1 hstx_enable net010 inh_bulk_n inh_bulk_p VDD VSS INV1
  XI2 en_override_i en_i hstx_enable inh_bulk_n inh_bulk_p VDD VSS AND2I
  XI4 trans_p_p trans_p_n inh_bulk_n inh_bulk_p VDD VSS INV10
  XI3 trans_n_n trans_n_p inh_bulk_n inh_bulk_p VDD VSS INV10
  C1<1> cap_tran cap_res C='151.9f' W='5.09u' L='5.09u'
  C1<0> cap_tran cap_res C='151.9f' W='5.09u' L='5.09u'
  C0<1> cap_res cap_tran C='151.9f' W='5.09u' L='5.09u'
  C0<0> cap_res cap_tran C='151.9f' W='5.09u' L='5.09u'
  XI6 data_i net010 trans_n_n inh_bulk_n inh_bulk_p VDD VSS NOR2P
  Vi_sink_80u net0167 net0120 DC 0
  Vi_src_80u net0105 net0185 DC 0
  VIMess_p net052 pre_pad DC 0
  VIMess_n pre_pad net0108 DC 0
  R4 cap_res pre_pad R='502.5'
  R2 pre_pad pad R='120'
  R6 net091 net021 R='24.98K'
  R5 ibias_10u_lptx net0139 R='24.98K'
  MP2 gate_p trans_p_p cap_tran inh_bulk_p PREG W='5u' L='120.0n' M='1'
  MP0 gate_p trans_p_n ldo_1v2 inh_bulk_p PREG W='20u' L='120.0n' M='1'
  MP1 gate_n trans_n_p net0185 inh_bulk_p PREG W='20u' L='120.0n' M='1'
  MP4 net052 gate_p ldo_1v2 inh_bulk_p PREG W='199.8u' L='150n' M='1'
  MP3 gate_n trans_n_p cap_tran inh_bulk_p PREG W='5u' L='120.0n' M='1'
  MN11 net021 hstx_enable net0145 inh_bulk_n NREG W='4u' L='120.0n' M='1'
  MN0 gate_n trans_n_p VSS inh_bulk_n NREG W='10u' L='120.0n' M='1'
  MN5<7> net0120 ibias_10u_lptx net060<7> inh_bulk_n NREG W='1.2u' L='280.0n' M='1'
  MN5<6> net0120 ibias_10u_lptx net060<6> inh_bulk_n NREG W='1.2u' L='280.0n' M='1'
  MN5<5> net0120 ibias_10u_lptx net060<5> inh_bulk_n NREG W='1.2u' L='280.0n' M='1'
  MN5<4> net0120 ibias_10u_lptx net060<4> inh_bulk_n NREG W='1.2u' L='280.0n' M='1'
  MN5<3> net0120 ibias_10u_lptx net060<3> inh_bulk_n NREG W='1.2u' L='280.0n' M='1'
  MN5<2> net0120 ibias_10u_lptx net060<2> inh_bulk_n NREG W='1.2u' L='280.0n' M='1'
  MN5<1> net0120 ibias_10u_lptx net060<1> inh_bulk_n NREG W='1.2u' L='280.0n' M='1'
  MN5<0> net0120 ibias_10u_lptx net060<0> inh_bulk_n NREG W='1.2u' L='280.0n' M='1'
  MN8 net0145 ibias_10u_lptx net0123 inh_bulk_n NREG W='1.2u' L='280.0n' M='1'
  MN2 gate_p trans_p_n cap_tran inh_bulk_n NREG W='2.5u' L='120.0n' M='1'
  MN1 gate_p trans_p_n net0167 inh_bulk_n NREG W='20u' L='120.0n' M='1'
  MN3 gate_n trans_n_n cap_tran inh_bulk_n NREG W='2.5u' L='120.0n' M='1'
  MN4 net0108 gate_n VSS inh_bulk_n NREG W='99.9u' L='150n' M='1'
  MN7 net0123 net0139 VSS inh_bulk_n NREG W='1.2u' L='1u' M='1'
  MN6<7> net060<7> net0139 VSS inh_bulk_n NREG W='1.2u' L='1u' M='1'
  MN6<6> net060<6> net0139 VSS inh_bulk_n NREG W='1.2u' L='1u' M='1'
  MN6<5> net060<5> net0139 VSS inh_bulk_n NREG W='1.2u' L='1u' M='1'
  MN6<4> net060<4> net0139 VSS inh_bulk_n NREG W='1.2u' L='1u' M='1'
  MN6<3> net060<3> net0139 VSS inh_bulk_n NREG W='1.2u' L='1u' M='1'
  MN6<2> net060<2> net0139 VSS inh_bulk_n NREG W='1.2u' L='1u' M='1'
  MN6<1> net060<1> net0139 VSS inh_bulk_n NREG W='1.2u' L='1u' M='1'
  MN6<0> net060<0> net0139 VSS inh_bulk_n NREG W='1.2u' L='1u' M='1'
  MN9 net0139 ibias_10u_lptx net0136 inh_bulk_n NREG W='1.2u' L='280.0n' M='1'
  MN10 net0136 net0139 VSS inh_bulk_n NREG W='1.2u' L='1u' M='1'
  MP5<7> net063<7> net091 ldo_1v2 ldo_1v2 PREG W='4u' L='1u' M='1'
  MP5<6> net063<6> net091 ldo_1v2 ldo_1v2 PREG W='4u' L='1u' M='1'
  MP5<5> net063<5> net091 ldo_1v2 ldo_1v2 PREG W='4u' L='1u' M='1'
  MP5<4> net063<4> net091 ldo_1v2 ldo_1v2 PREG W='4u' L='1u' M='1'
  MP5<3> net063<3> net091 ldo_1v2 ldo_1v2 PREG W='4u' L='1u' M='1'
  MP5<2> net063<2> net091 ldo_1v2 ldo_1v2 PREG W='4u' L='1u' M='1'
  MP5<1> net063<1> net091 ldo_1v2 ldo_1v2 PREG W='4u' L='1u' M='1'
  MP5<0> net063<0> net091 ldo_1v2 ldo_1v2 PREG W='4u' L='1u' M='1'
  MP8<7> net0105 net021 net063<7> ldo_1v2 PREG W='4u' L='160.0n' M='1'
  MP8<6> net0105 net021 net063<6> ldo_1v2 PREG W='4u' L='160.0n' M='1'
  MP8<5> net0105 net021 net063<5> ldo_1v2 PREG W='4u' L='160.0n' M='1'
  MP8<4> net0105 net021 net063<4> ldo_1v2 PREG W='4u' L='160.0n' M='1'
  MP8<3> net0105 net021 net063<3> ldo_1v2 PREG W='4u' L='160.0n' M='1'
  MP8<2> net0105 net021 net063<2> ldo_1v2 PREG W='4u' L='160.0n' M='1'
  MP8<1> net0105 net021 net063<1> ldo_1v2 PREG W='4u' L='160.0n' M='1'
  MP8<0> net0105 net021 net063<0> ldo_1v2 PREG W='4u' L='160.0n' M='1'
  MP7 net091 net021 net074 ldo_1v2 PREG W='4u' L='160.0n' M='1'
  MP6 net074 net091 ldo_1v2 ldo_1v2 PREG W='4u' L='1u' M='1'
  C2 pre_pad VSS C='100f'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_bias_lane_distributor
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_bias_lane_distributor VDD VSS ibias1_10u_i ibias2_10u_i ibias1_25u_o ibias2_25u_o ibias3_10u_o ibias5_10u_o<1> ibias5_10u_o<0> pwd_i ibias6_10u_o inh_bulk_n inh_bulk_p
  XI46<1> VDD ibias3_10u_o net17 net43 inh_bulk_p phy_bias_distributor_pmirr
  XI46<0> VDD ibias3_10u_o net17 net43 inh_bulk_p phy_bias_distributor_pmirr
  XI48<1> VDD net24 net17 net43 inh_bulk_p phy_bias_distributor_pmirr
  XI48<0> VDD net24 net17 net43 inh_bulk_p phy_bias_distributor_pmirr
  XI47<1> VDD net25 net17 net43 inh_bulk_p phy_bias_distributor_pmirr
  XI47<0> VDD net25 net17 net43 inh_bulk_p phy_bias_distributor_pmirr
  XI39<1> VDD ibias6_10u_o net17 net43 inh_bulk_p phy_bias_distributor_pmirr
  XI39<0> VDD ibias6_10u_o net17 net43 inh_bulk_p phy_bias_distributor_pmirr
  XI51<15> VDD inh_bulk_p phy_bias_distributor_pmirr_dy
  XI51<14> VDD inh_bulk_p phy_bias_distributor_pmirr_dy
  XI51<13> VDD inh_bulk_p phy_bias_distributor_pmirr_dy
  XI51<12> VDD inh_bulk_p phy_bias_distributor_pmirr_dy
  XI51<11> VDD inh_bulk_p phy_bias_distributor_pmirr_dy
  XI51<10> VDD inh_bulk_p phy_bias_distributor_pmirr_dy
  XI51<9> VDD inh_bulk_p phy_bias_distributor_pmirr_dy
  XI51<8> VDD inh_bulk_p phy_bias_distributor_pmirr_dy
  XI51<7> VDD inh_bulk_p phy_bias_distributor_pmirr_dy
  XI51<6> VDD inh_bulk_p phy_bias_distributor_pmirr_dy
  XI51<5> VDD inh_bulk_p phy_bias_distributor_pmirr_dy
  XI51<4> VDD inh_bulk_p phy_bias_distributor_pmirr_dy
  XI51<3> VDD inh_bulk_p phy_bias_distributor_pmirr_dy
  XI51<2> VDD inh_bulk_p phy_bias_distributor_pmirr_dy
  XI51<1> VDD inh_bulk_p phy_bias_distributor_pmirr_dy
  XI51<0> VDD inh_bulk_p phy_bias_distributor_pmirr_dy
  XI14<90> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<89> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<88> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<87> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<86> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<85> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<84> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<83> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<82> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<81> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<80> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<79> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<78> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<77> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<76> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<75> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<74> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<73> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<72> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<71> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<70> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<69> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<68> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<67> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<66> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<65> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<64> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<63> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<62> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<61> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<60> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<59> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<58> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<57> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<56> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<55> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<54> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<53> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<52> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<51> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<50> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<49> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<48> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<47> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<46> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<45> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<44> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<43> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<42> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<41> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<40> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<39> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<38> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<37> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<36> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<35> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<34> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<33> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<32> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<31> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<30> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<29> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<28> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<27> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<26> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<25> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<24> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<23> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<22> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<21> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<20> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<19> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<18> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<17> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<16> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<15> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<14> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<13> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<12> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<11> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<10> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<9> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<8> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<7> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<6> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<5> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<4> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<3> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<2> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<1> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<0> VDD VSS inh_bulk_p phy_supplybl_m2
  MN4<23> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN4<22> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN4<21> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN4<20> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN4<19> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN4<18> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN4<17> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN4<16> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN4<15> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN4<14> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN4<13> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN4<12> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN4<11> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN4<10> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN4<9> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN4<8> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN4<7> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN4<6> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN4<5> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN4<4> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN4<3> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN4<2> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN4<1> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  MN4<0> VDD VDD VDD inh_bulk_n NANA W='1.65u' L='2u' M='1'
  Xbiasamux VDD VSS net17 net43 ibias1_10u_i ibias1_25u_o ibias2_10u_i ibias2_25u_o pwd_i inh_bulk_n inh_bulk_p phy_bias_distributor
  VIMess28 net24 ibias5_10u_o<1> DC 0
  VIMess27 net25 ibias5_10u_o<0> DC 0
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_symmetrical_mux
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_symmetrical_mux VDD VSS a0 a1 s z inh_bulk_n inh_bulk_p
  MN0<1> net025<1> a0 VSS inh_bulk_n NREG W='680.0n' L='120.0n' M='1'
  MN0<0> net025<0> a0 VSS inh_bulk_n NREG W='680.0n' L='120.0n' M='1'
  MN1<1> z s net023<1> inh_bulk_n NREG W='680.0n' L='120.0n' M='1'
  MN1<0> z s net023<0> inh_bulk_n NREG W='680.0n' L='120.0n' M='1'
  Mntrans0<1> z net041 net025<1> inh_bulk_n NREG W='680.0n' L='120.0n' M='1'
  Mntrans0<0> z net041 net025<0> inh_bulk_n NREG W='680.0n' L='120.0n' M='1'
  MN2<1> net023<1> a1 VSS inh_bulk_n NREG W='680.0n' L='120.0n' M='1'
  MN2<0> net023<0> a1 VSS inh_bulk_n NREG W='680.0n' L='120.0n' M='1'
  Mntrans53 net041 s VSS inh_bulk_n NREG W='900n' L='120.0n' M='1'
  Mptrans4 net041 s VDD inh_bulk_p PREG W='1.28u' L='120.0n' M='1'
  Mptrans0<1> net026<1> a0 VDD inh_bulk_p PREG W='1.38u' L='120.0n' M='1'
  Mptrans0<0> net026<0> a0 VDD inh_bulk_p PREG W='1.38u' L='120.0n' M='1'
  MP2<1> z net041 net024<1> inh_bulk_p PREG W='1.38u' L='120.0n' M='1'
  MP2<0> z net041 net024<0> inh_bulk_p PREG W='1.38u' L='120.0n' M='1'
  MP0<1> z s net026<1> inh_bulk_p PREG W='1.38u' L='120.0n' M='1'
  MP0<0> z s net026<0> inh_bulk_p PREG W='1.38u' L='120.0n' M='1'
  MP1<1> net024<1> a1 VDD inh_bulk_p PREG W='1.38u' L='120.0n' M='1'
  MP1<0> net024<0> a1 VDD inh_bulk_p PREG W='1.38u' L='120.0n' M='1'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_symmetrical_and
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_symmetrical_and VDD VSS a b z inh_bulk_n inh_bulk_p
  Mntrans20 net20 b VSS inh_bulk_n NREG W='810.0n' L='120.0n' M='1'
  Mntrans21 net9 a net20 inh_bulk_n NREG W='810.0n' L='120.0n' M='1'
  Mntrans22 z net9 VSS inh_bulk_n NREG W='960.0n' L='120.0n' M='1'
  Mptrans23 net9 b VDD inh_bulk_p PREG W='1.2u' L='120.0n' M='1'
  Mptrans24 net9 a VDD inh_bulk_p PREG W='1.2u' L='120.0n' M='1'
  Mptrans25 z net9 VDD inh_bulk_p PREG W='2.2u' L='120.0n' M='1'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: OR3
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT OR3 A B C Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mptrans21 net026 A net37 inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  Mptrans20 net37 B net34 inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  Mptrans19 net34 C inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  MP0 Z net026 inh_hSup inh_bulk_p PREG W='860.0n' L='120.0n' M='1'
  Mntrans24 net026 A inh_lSup inh_bulk_n NREG W='860.0n' L='120.0n' M='1'
  Mntrans23 net026 B inh_lSup inh_bulk_n NREG W='860.0n' L='120.0n' M='1'
  Mntrans22 net026 C inh_lSup inh_bulk_n NREG W='860.0n' L='120.0n' M='1'
  MN0 Z net026 inh_lSup inh_bulk_n NREG W='600n' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='6.3e-12'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: AND3
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT AND3 A B C Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mntrans70 Z net49 inh_lSup inh_bulk_n NREG W='600n' L='120.0n' M='1'
  Mntrans69 net45 C inh_lSup inh_bulk_n NREG W='700n' L='120.0n' M='1'
  Mntrans68 net42 B net45 inh_bulk_n NREG W='700n' L='120.0n' M='1'
  Mntrans67 net49 A net42 inh_bulk_n NREG W='700n' L='120.0n' M='1'
  Mptrans74 Z net49 inh_hSup inh_bulk_p PREG W='860.0n' L='120.0n' M='1'
  Mptrans73 net49 C inh_hSup inh_bulk_p PREG W='700n' L='120.0n' M='1'
  Mptrans72 net49 A inh_hSup inh_bulk_p PREG W='700n' L='120.0n' M='1'
  Mptrans71 net49 B inh_hSup inh_bulk_p PREG W='700n' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='5.4e-12'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: INV6
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT INV6 A Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mptrans10 Z A inh_hSup inh_bulk_p PREG W='4.86u' L='120.0n' M='1'
  Mntrans11 Z A inh_lSup inh_bulk_n NREG W='3.36u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='4.5e-12'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: BUF2
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT BUF2 A Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mptrans15 net24 A inh_hSup inh_bulk_p PREG W='1.2u' L='120.0n' M='1'
  Mptrans14 Z net24 inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  Mntrans13 net24 A inh_lSup inh_bulk_n NREG W='820.0n' L='120.0n' M='1'
  Mntrans12 Z net24 inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  XINSTANCE1 inh_hSup inh_lSup inh_bulk_n sub_diode
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_prog_delay_line_with_bypass
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_prog_delay_line_with_bypass VDD VSS bypass_delay_line_i data_i data_n_o delay_prog<2> delay_prog<1> delay_prog<0> inh_bulk_n inh_bulk_p
  XI40<1> VDD VSS net0260 data_i bypass_delay_line_i data_n_o inh_bulk_n inh_bulk_p phy_symmetrical_mux
  XI40<0> VDD VSS net0260 data_i bypass_delay_line_i data_n_o inh_bulk_n inh_bulk_p phy_symmetrical_mux
  XI4 VDD VSS net0114 net075 delay_prog<1> net078 inh_bulk_n inh_bulk_p phy_symmetrical_mux
  XI9 VDD VSS delay_int<4> delay_int<5> delay_prog<0> net094 inh_bulk_n inh_bulk_p phy_symmetrical_mux
  XI7 VDD VSS net094 net070 delay_prog<1> net073 inh_bulk_n inh_bulk_p phy_symmetrical_mux
  XI8 VDD VSS delay_int<6> delay_int<7> delay_prog<0> net070 inh_bulk_n inh_bulk_p phy_symmetrical_mux
  XI27 VDD VSS delay_int<0> delay_int<1> delay_prog<0> net0114 inh_bulk_n inh_bulk_p phy_symmetrical_mux
  XI13 VDD VSS net078 net073 delay_prog<2> net0260 inh_bulk_n inh_bulk_p phy_symmetrical_mux
  XI28 VDD VSS delay_int<2> delay_int<3> delay_prog<0> net075 inh_bulk_n inh_bulk_p phy_symmetrical_mux
  XI18 VDD VSS net096 net064 delay_int<4> inh_bulk_n inh_bulk_p phy_symmetrical_and
  XI17 VDD VSS net098 net062 delay_int<5> inh_bulk_n inh_bulk_p phy_symmetrical_and
  XI14 VDD VSS net071 net066 delay_int<3> inh_bulk_n inh_bulk_p phy_symmetrical_and
  XI21 VDD VSS net099 net067 delay_int<7> inh_bulk_n inh_bulk_p phy_symmetrical_and
  XI12 VDD VSS net069 net063 delay_int<1> inh_bulk_n inh_bulk_p phy_symmetrical_and
  XI31 VDD VSS net074 net057 delay_int<6> inh_bulk_n inh_bulk_p phy_symmetrical_and
  XI15 VDD VSS net0100 net061 delay_int<2> inh_bulk_n inh_bulk_p phy_symmetrical_and
  XI2 VDD VSS net068 net076 delay_int<0> inh_bulk_n inh_bulk_p phy_symmetrical_and
  C16 delay_int<4> VSS C='3f'
  C15 delay_int<5> VSS C='3f'
  C14 delay_int<6> VSS C='3f'
  C13 delay_int<7> VSS C='3f'
  C12 delay_int<3> VSS C='3f'
  C11 delay_int<2> VSS C='3f'
  C9 delay_int<0> VSS C='3f'
  C7 net070 VSS C='3f'
  C4 net0114 VSS C='3f'
  C1 net073 VSS C='3f'
  C6 net075 VSS C='3f'
  C5 net094 VSS C='3f'
  C2 net078 VSS C='3f'
  C0 net0260 VSS C='3f'
  C10 delay_int<1> VSS C='3f'
  XI42 delay_prog<2> delay_prog<1> delay_prog<0> net063 inh_bulk_n inh_bulk_p VDD VSS OR3
  XI22 delay_prog<2> delay_prog<1> delay_prog<0> net067 inh_bulk_n inh_bulk_p VDD VSS AND3
  XI19 delay_prog<2> delay_prog_n_s<1> delay_prog<0> net0111 inh_bulk_n inh_bulk_p VDD VSS AND3
  XI48 delay_prog_n_s<2> delay_prog<1> delay_prog<0> net0103 inh_bulk_n inh_bulk_p VDD VSS AND3
  XI50 delay_prog<2> delay_prog<1> net057 inh_bulk_n inh_bulk_p VDD VSS AND2
  XI60 data_i net072 inh_bulk_n inh_bulk_p VDD VSS INV6
  XI5<2> delay_prog<2> delay_prog_n_s<2> inh_bulk_n inh_bulk_p VDD VSS INV1
  XI5<1> delay_prog<1> delay_prog_n_s<1> inh_bulk_n inh_bulk_p VDD VSS INV1
  XI5<0> delay_prog<0> delay_prog_n_s<0> inh_bulk_n inh_bulk_p VDD VSS INV1
  XI61 bypass_delay_line_i net076 inh_bulk_n inh_bulk_p VDD VSS INV2
  XI16 net0111 net057 net062 inh_bulk_n inh_bulk_p VDD VSS OR2
  XI46 delay_prog<2> delay_prog<1> net061 inh_bulk_n inh_bulk_p VDD VSS OR2
  XI47 delay_prog<2> net0103 net066 inh_bulk_n inh_bulk_p VDD VSS OR2
  XI77 net059 net099 inh_bulk_n inh_bulk_p VDD VSS BUF2
  XI76 net056 net074 inh_bulk_n inh_bulk_p VDD VSS BUF2
  XI75 net054 net098 inh_bulk_n inh_bulk_p VDD VSS BUF2
  XI74 net052 net096 inh_bulk_n inh_bulk_p VDD VSS BUF2
  XI73 net051 net071 inh_bulk_n inh_bulk_p VDD VSS BUF2
  XI72 net048 net0100 inh_bulk_n inh_bulk_p VDD VSS BUF2
  XI71 net046 net069 inh_bulk_n inh_bulk_p VDD VSS BUF2
  XI70 net077 net068 inh_bulk_n inh_bulk_p VDD VSS BUF2
  XI69 delay_int<6> net059 inh_bulk_n inh_bulk_p VDD VSS BUF2
  XI68 delay_int<5> net056 inh_bulk_n inh_bulk_p VDD VSS BUF2
  XI67 delay_int<4> net054 inh_bulk_n inh_bulk_p VDD VSS BUF2
  XI66 delay_int<3> net052 inh_bulk_n inh_bulk_p VDD VSS BUF2
  XI65 delay_int<2> net051 inh_bulk_n inh_bulk_p VDD VSS BUF2
  XI64 delay_int<1> net048 inh_bulk_n inh_bulk_p VDD VSS BUF2
  XI63 delay_int<0> net046 inh_bulk_n inh_bulk_p VDD VSS BUF2
  XI62 net072 net077 inh_bulk_n inh_bulk_p VDD VSS BUF2
  VIMess0 net064 delay_prog<2> DC 0
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: npdiorf01
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT npdiorf01 N bulk nwell inh_bulk_n
  XD0 bulk N inh_bulk_n DIODE_X
  C0 nwell bulk C='100e-18'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_esd_hf16diodes_tovss
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_esd_hf16diodes_tovss VDD VSS pad inh_bulk_n
  XI73 pad VSS VDD inh_bulk_n npdiorf01
  XI67 pad VSS VDD inh_bulk_n npdiorf01
  XI61 pad VSS VDD inh_bulk_n npdiorf01
  XI55 pad VSS VDD inh_bulk_n npdiorf01
  XI39 pad VSS VDD inh_bulk_n npdiorf01
  XI38 pad VSS VDD inh_bulk_n npdiorf01
  XI37 pad VSS VDD inh_bulk_n npdiorf01
  XI36 pad VSS VDD inh_bulk_n npdiorf01
  XI27 pad VSS VDD inh_bulk_n npdiorf01
  XI24 pad VSS VDD inh_bulk_n npdiorf01
  XI40 pad VSS VDD inh_bulk_n npdiorf01
  XI41 pad VSS VDD inh_bulk_n npdiorf01
  XI42 pad VSS VDD inh_bulk_n npdiorf01
  XI43 pad VSS VDD inh_bulk_n npdiorf01
  XI21 pad VSS VDD inh_bulk_n npdiorf01
  XI18 pad VSS VDD inh_bulk_n npdiorf01
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_esd_hf4diodes_tovss
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_esd_hf4diodes_tovss VDD VSS pad inh_bulk_n
  XI39 pad VSS VDD inh_bulk_n npdiorf01
  XI38 pad VSS VDD inh_bulk_n npdiorf01
  XI37 pad VSS VDD inh_bulk_n npdiorf01
  XI36 pad VSS VDD inh_bulk_n npdiorf01
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: pndiorf01
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT pndiorf01 P bulk nwell inh_bulk_n
  XD0 P nwell inh_bulk_n DIODE_X
  C0 bulk P C='100e-18'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_esd_hf4diodes_tovdd
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_esd_hf4diodes_tovdd VDD VSS pad inh_bulk_n
  XI36 pad VSS VDD inh_bulk_n pndiorf01
  XI33 pad VSS VDD inh_bulk_n pndiorf01
  XI30 pad VSS VDD inh_bulk_n pndiorf01
  XI39 pad VSS VDD inh_bulk_n pndiorf01
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_esd_hf16diodes_tovdd
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_esd_hf16diodes_tovdd VDD VSS pad inh_bulk_n
  XI73 pad VSS VDD inh_bulk_n pndiorf01
  XI68 pad VSS VDD inh_bulk_n pndiorf01
  XI62 pad VSS VDD inh_bulk_n pndiorf01
  XI56 pad VSS VDD inh_bulk_n pndiorf01
  XI36 pad VSS VDD inh_bulk_n pndiorf01
  XI33 pad VSS VDD inh_bulk_n pndiorf01
  XI30 pad VSS VDD inh_bulk_n pndiorf01
  XI27 pad VSS VDD inh_bulk_n pndiorf01
  XI23 pad VSS VDD inh_bulk_n pndiorf01
  XI51 pad VSS VDD inh_bulk_n pndiorf01
  XI20 pad VSS VDD inh_bulk_n pndiorf01
  XI17 pad VSS VDD inh_bulk_n pndiorf01
  XI39 pad VSS VDD inh_bulk_n pndiorf01
  XI42 pad VSS VDD inh_bulk_n pndiorf01
  XI45 pad VSS VDD inh_bulk_n pndiorf01
  XI48 pad VSS VDD inh_bulk_n pndiorf01
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_esd_hf16diodes
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_esd_hf16diodes VDD VSS outi pad inh_bulk_n
  XI7 VDD VSS pad inh_bulk_n phy_esd_hf16diodes_tovss
  XI11 VDD VSS pad inh_bulk_n phy_esd_hf4diodes_tovss
  XI10 VDD VSS pad inh_bulk_n phy_esd_hf4diodes_tovdd
  RESD_R3 outi pad R='1.362m'
  C0 pad VSS C='200f'
  XI8 VDD VSS pad inh_bulk_n phy_esd_hf16diodes_tovdd
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: FD2QB
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT FD2QB CP D Q RN inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mntrans65 D1 D inh_lSup inh_bulk_n NREG W='800n' L='120.0n' M='1'
  Mntrans158 SF2 CP1 net206 inh_bulk_n NREG W='400n' L='120.0n' M='1'
  Mntrans128 MB2 MF1 inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  MN5 MF1 CP1 D1 inh_bulk_n NREG W='500n' L='120.0n' M='1'
  Mntrans156 net206 SB3 inh_lSup inh_bulk_n NREG W='400n' L='120.0n' M='1'
  Mntrans119 CP1 CP inh_lSup inh_bulk_n NREG W='650.0n' L='120.0n' M='1'
  Mntrans155 net188 RN net200 inh_bulk_n NREG W='500n' L='120.0n' M='1'
  Mntrans154 MF1 CP2 net188 inh_bulk_n NREG W='500n' L='120.0n' M='1'
  Mntrans123 CP2 CP1 inh_lSup inh_bulk_n NREG W='500n' L='120.0n' M='1'
  MN0 net158 RN inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  MN1 SB3 SF2 net158 inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  Mntrans153 net200 MB2 inh_lSup inh_bulk_n NREG W='500n' L='120.0n' M='1'
  MN3 SF2 CP2 MB2 inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  MN4 Q SB3 inh_lSup inh_bulk_n NREG W='2.24u' L='120.0n' M='1'
  Mptrans63 D1 D inh_hSup inh_bulk_p PREG W='1.2u' L='120.0n' M='1'
  Mptrans151 net153 RN inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  Mptrans118 CP1 CP inh_hSup inh_bulk_p PREG W='900n' L='120.0n' M='1'
  MP4 SF2 CP2 net105 inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP6 MF1 CP2 D1 inh_bulk_p PREG W='500n' L='120.0n' M='1'
  Mptrans127 MB2 MF1 inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  Mptrans152 net153 MB2 inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP1 SB3 SF2 inh_hSup inh_bulk_p PREG W='1.52u' L='120.0n' M='1'
  Mptrans122 CP2 CP1 inh_hSup inh_bulk_p PREG W='750.0n' L='120.0n' M='1'
  MP0 SB3 RN inh_hSup inh_bulk_p PREG W='1.52u' L='120.0n' M='1'
  Mptrans160 net105 SB3 inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  Mptrans150 MF1 CP1 net153 inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP3 SF2 CP1 MB2 inh_bulk_p PREG W='1.12u' L='120.0n' M='1'
  MP5 Q SB3 inh_hSup inh_bulk_p PREG W='3.24u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='2.07e-11'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: AND2V
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT AND2V A B Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mntrans22 Z net39 inh_lSup inh_bulk_n NREG W='4.48u' L='120.0n' M='1'
  Mntrans21 net39 A net32 inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  Mntrans20 net32 B inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  MN1 net39 A net035 inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  MN0 net035 B inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  Mptrans25 Z net39 inh_hSup inh_bulk_p PREG W='6.48u' L='120.0n' M='1'
  Mptrans24 net39 A inh_hSup inh_bulk_p PREG W='3.24u' L='120.0n' M='1'
  Mptrans23 net39 B inh_hSup inh_bulk_p PREG W='3.24u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='9.9e-12'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: FD2QNSP
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT FD2QNSP CP D QN RN TE TI inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mntrans158 SF2 CP1 net206 inh_bulk_n NREG W='400n' L='120.0n' M='1'
  Mntrans128 MB2 MF1 inh_lSup inh_bulk_n NREG W='1u' L='120.0n' M='1'
  MN5 MF1 CP1 ID1 inh_bulk_n NREG W='500n' L='120.0n' M='1'
  Mntrans156 net206 SB3 inh_lSup inh_bulk_n NREG W='400n' L='120.0n' M='1'
  Mntrans119 CP1 CP inh_lSup inh_bulk_n NREG W='650.0n' L='120.0n' M='1'
  Mntrans155 net188 RN net200 inh_bulk_n NREG W='500n' L='120.0n' M='1'
  Mntrans154 MF1 CP2 net188 inh_bulk_n NREG W='500n' L='120.0n' M='1'
  MN6 ID1 TE1 D1 inh_bulk_n NREG W='600n' L='120.0n' M='1'
  MN7 TI1 TI inh_lSup inh_bulk_n NREG W='400n' L='120.0n' M='1'
  MN8 TE1 TE inh_lSup inh_bulk_n NREG W='300n' L='120.0n' M='1'
  MN9 ID1 TE TI1 inh_bulk_n NREG W='300n' L='120.0n' M='1'
  MN2 D1 D inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  Mntrans123 CP2 CP1 inh_lSup inh_bulk_n NREG W='500n' L='120.0n' M='1'
  MN0 net158 RN inh_lSup inh_bulk_n NREG W='400n' L='120.0n' M='1'
  MN1 SB3 SF2 net158 inh_bulk_n NREG W='400n' L='120.0n' M='1'
  Mntrans153 net200 MB2 inh_lSup inh_bulk_n NREG W='500n' L='120.0n' M='1'
  MN3 SF2 CP2 MB2 inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  MN4 QN SF2 inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  MP10 ID1 TE1 TI1 inh_bulk_p PREG W='300n' L='120.0n' M='1'
  Mptrans151 net153 RN inh_hSup inh_bulk_p PREG W='1u' L='120.0n' M='1'
  MP9 TE1 TE inh_hSup inh_bulk_p PREG W='450.0n' L='120.0n' M='1'
  Mptrans118 CP1 CP inh_hSup inh_bulk_p PREG W='900n' L='120.0n' M='1'
  MP4 SF2 CP2 net105 inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP6 MF1 CP2 ID1 inh_bulk_p PREG W='500n' L='120.0n' M='1'
  MP8 TI1 TI inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  Mptrans127 MB2 MF1 inh_hSup inh_bulk_p PREG W='1.3u' L='120.0n' M='1'
  Mptrans152 net153 MB2 inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP2 D1 D inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  MP1 SB3 SF2 inh_hSup inh_bulk_p PREG W='400n' L='120.0n' M='1'
  Mptrans122 CP2 CP1 inh_hSup inh_bulk_p PREG W='750.0n' L='120.0n' M='1'
  MP7 ID1 TE D1 inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP0 SB3 RN inh_hSup inh_bulk_p PREG W='400n' L='120.0n' M='1'
  Mptrans160 net105 SB3 inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  Mptrans150 MF1 CP1 net153 inh_bulk_p PREG W='880.0n' L='120.0n' M='1'
  MP3 SF2 CP1 MB2 inh_bulk_p PREG W='1.12u' L='120.0n' M='1'
  MP5 QN SF2 inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='2.43608e-11'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_serializer_clkmux
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_serializer_clkmux VDD VSS a0 a1 s z inh_bulk_n inh_bulk_p
  MN0 z net010 VSS inh_bulk_n NREG W='2.72u' L='120.0n' M='1'
  Mntrans3 net017 a1 VSS inh_bulk_n NREG W='2.72u' L='120.0n' M='1'
  Mntrans0 net010 net041 net018 inh_bulk_n NREG W='2.72u' L='120.0n' M='1'
  Mntrans1 net018 a0 VSS inh_bulk_n NREG W='2.72u' L='120.0n' M='1'
  Mntrans53 net041 s VSS inh_bulk_n NREG W='1.36u' L='120.0n' M='1'
  Mntrans2 net010 s net017 inh_bulk_n NREG W='2.72u' L='120.0n' M='1'
  Mptrans1 net010 s net013 inh_bulk_p PREG W='5.36u' L='120.0n' M='1'
  Mptrans4 net041 s VDD inh_bulk_p PREG W='2.76u' L='120.0n' M='1'
  MP0 z net010 VDD inh_bulk_p PREG W='5.36u' L='120.0n' M='1'
  Mptrans2 net014 a1 VDD inh_bulk_p PREG W='5.36u' L='120.0n' M='1'
  Mptrans3 net010 net041 net014 inh_bulk_p PREG W='5.36u' L='120.0n' M='1'
  Mptrans0 net013 a0 VDD inh_bulk_p PREG W='5.36u' L='120.0n' M='1'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: MXI2P
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT MXI2P A0 A1 S Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mptrans57 Z S net72 inh_bulk_p PREG W='1.32u' L='120.0n' M='1'
  Mptrans56 net66 A1 inh_hSup inh_bulk_p PREG W='1.32u' L='120.0n' M='1'
  Mptrans55 Z net64 net66 inh_bulk_p PREG W='1.32u' L='120.0n' M='1'
  Mptrans54 net72 A0 inh_hSup inh_bulk_p PREG W='1.32u' L='120.0n' M='1'
  Mptrans74 net64 S inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  MP3 net71 A1 inh_hSup inh_bulk_p PREG W='1.32u' L='120.0n' M='1'
  MP2 Z net64 net71 inh_bulk_p PREG W='1.32u' L='120.0n' M='1'
  MP1 Z S net74 inh_bulk_p PREG W='1.32u' L='120.0n' M='1'
  MP0 net74 A0 inh_hSup inh_bulk_p PREG W='1.32u' L='120.0n' M='1'
  Mntrans61 Z net64 net44 inh_bulk_n NREG W='920.0n' L='120.0n' M='1'
  Mntrans73 net64 S inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  Mntrans60 Z S net47 inh_bulk_n NREG W='920.0n' L='120.0n' M='1'
  Mntrans59 net47 A1 inh_lSup inh_bulk_n NREG W='920.0n' L='120.0n' M='1'
  Mntrans58 net44 A0 inh_lSup inh_bulk_n NREG W='920.0n' L='120.0n' M='1'
  MN3 Z S net129 inh_bulk_n NREG W='920.0n' L='120.0n' M='1'
  MN2 net129 A1 inh_lSup inh_bulk_n NREG W='920.0n' L='120.0n' M='1'
  MN1 Z net64 net50 inh_bulk_n NREG W='920.0n' L='120.0n' M='1'
  MN0 net50 A0 inh_lSup inh_bulk_n NREG W='920.0n' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='9.9e-12'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: FD2QS
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT FD2QS CP D Q RN TE TI inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mntrans158 SF2 CP1 net206 inh_bulk_n NREG W='400n' L='120.0n' M='1'
  Mntrans128 MB2 MF1 inh_lSup inh_bulk_n NREG W='560.0n' L='120.0n' M='1'
  MN5 MF1 CP1 ID1 inh_bulk_n NREG W='400n' L='120.0n' M='1'
  Mntrans156 net206 SB3 inh_lSup inh_bulk_n NREG W='400n' L='120.0n' M='1'
  Mntrans119 CP1 CP inh_lSup inh_bulk_n NREG W='500n' L='120.0n' M='1'
  Mntrans155 net188 RN net200 inh_bulk_n NREG W='500n' L='120.0n' M='1'
  Mntrans154 MF1 CP2 net188 inh_bulk_n NREG W='500n' L='120.0n' M='1'
  MN6 ID1 TE1 D1 inh_bulk_n NREG W='600n' L='120.0n' M='1'
  MN7 TI1 TI inh_lSup inh_bulk_n NREG W='400n' L='120.0n' M='1'
  MN2 D1 D inh_lSup inh_bulk_n NREG W='700n' L='120.0n' M='1'
  MN9 ID1 TE TI1 inh_bulk_n NREG W='300n' L='120.0n' M='1'
  Mntrans123 CP2 CP1 inh_lSup inh_bulk_n NREG W='420.0n' L='120.0n' M='1'
  MN0 net158 RN inh_lSup inh_bulk_n NREG W='700n' L='120.0n' M='1'
  MN1 SB3 SF2 net158 inh_bulk_n NREG W='700n' L='120.0n' M='1'
  MN8 TE1 TE inh_lSup inh_bulk_n NREG W='300n' L='120.0n' M='1'
  Mntrans153 net200 MB2 inh_lSup inh_bulk_n NREG W='500n' L='120.0n' M='1'
  MN3 SF2 CP2 MB2 inh_bulk_n NREG W='660.0n' L='120.0n' M='1'
  MN4 Q SB3 inh_lSup inh_bulk_n NREG W='600n' L='120.0n' M='1'
  MP8 TI1 TI inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP7 ID1 TE D1 inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP10 ID1 TE1 TI1 inh_bulk_p PREG W='300n' L='120.0n' M='1'
  Mptrans151 net153 RN inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP2 D1 D inh_hSup inh_bulk_p PREG W='1u' L='120.0n' M='1'
  Mptrans118 CP1 CP inh_hSup inh_bulk_p PREG W='700n' L='120.0n' M='1'
  MP4 SF2 CP2 net105 inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP6 MF1 CP2 ID1 inh_bulk_p PREG W='400n' L='120.0n' M='1'
  Mptrans127 MB2 MF1 inh_hSup inh_bulk_p PREG W='800n' L='120.0n' M='1'
  Mptrans152 net153 MB2 inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP9 TE1 TE inh_hSup inh_bulk_p PREG W='450.0n' L='120.0n' M='1'
  MP1 SB3 SF2 inh_hSup inh_bulk_p PREG W='900n' L='120.0n' M='1'
  Mptrans122 CP2 CP1 inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP0 SB3 RN inh_hSup inh_bulk_p PREG W='900n' L='120.0n' M='1'
  Mptrans160 net105 SB3 inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  Mptrans150 MF1 CP1 net153 inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP3 SF2 CP1 MB2 inh_bulk_p PREG W='660.0n' L='120.0n' M='1'
  MP5 Q SB3 inh_hSup inh_bulk_p PREG W='860.0n' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='2.43e-11'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: DP2NQH
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT DP2NQH D ENN Q RN inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mntrans119 ENN1 ENN inh_lSup inh_bulk_n NREG W='600n' L='120.0n' M='1'
  Mntrans162 net127 MB2 net0101 inh_bulk_n NREG W='500n' L='120.0n' M='1'
  MN10 MF1 ENN1 net092 inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  MN5 Q MF1 inh_lSup inh_bulk_n NREG W='3.36u' L='120.0n' M='1'
  MN8 net0101 RN inh_lSup inh_bulk_n NREG W='500n' L='120.0n' M='1'
  MN9 net098 RN inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  Mntrans123 ENN2 ENN1 inh_lSup inh_bulk_n NREG W='500n' L='120.0n' M='1'
  Mntrans136 MB2 MF1 inh_lSup inh_bulk_n NREG W='400n' L='120.0n' M='1'
  Mntrans161 MF1 ENN2 net127 inh_bulk_n NREG W='500n' L='120.0n' M='1'
  MN11 net092 D net098 inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  MN14 MF1 ENN1 net0111 inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  MN13 net0108 RN inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  MN12 net0111 D net0108 inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  Mptrans118 ENN1 ENN inh_hSup inh_bulk_p PREG W='900n' L='120.0n' M='1'
  Mptrans163 MF1 ENN1 net98 inh_bulk_p PREG W='600n' L='120.0n' M='1'
  Mptrans164 net98 MB2 inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP11 MF1 ENN2 net068 inh_bulk_p PREG W='1.48u' L='120.0n' M='1'
  MP10 net068 D inh_hSup inh_bulk_p PREG W='1.48u' L='120.0n' M='1'
  MP12 MF1 RN inh_hSup inh_bulk_p PREG W='1.48u' L='120.0n' M='1'
  Mptrans122 ENN2 ENN1 inh_hSup inh_bulk_p PREG W='750.0n' L='120.0n' M='1'
  Mptrans135 MB2 MF1 inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP5 Q MF1 inh_hSup inh_bulk_p PREG W='4.86u' L='120.0n' M='1'
  MP14 MF1 ENN2 net072 inh_bulk_p PREG W='1.48u' L='120.0n' M='1'
  MP13 net072 D inh_hSup inh_bulk_p PREG W='1.48u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='1.8e-11'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: FD2QNP
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT FD2QNP CP D QN RN inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mntrans65 D1 D inh_lSup inh_bulk_n NREG W='800n' L='120.0n' M='1'
  Mntrans158 SF2 CP1 net206 inh_bulk_n NREG W='400n' L='120.0n' M='1'
  Mntrans128 MB2 MF1 inh_lSup inh_bulk_n NREG W='1u' L='120.0n' M='1'
  MN5 MF1 CP1 D1 inh_bulk_n NREG W='500n' L='120.0n' M='1'
  Mntrans156 net206 SB3 inh_lSup inh_bulk_n NREG W='400n' L='120.0n' M='1'
  Mntrans119 CP1 CP inh_lSup inh_bulk_n NREG W='650.0n' L='120.0n' M='1'
  Mntrans155 net188 RN net200 inh_bulk_n NREG W='500n' L='120.0n' M='1'
  Mntrans154 MF1 CP2 net188 inh_bulk_n NREG W='500n' L='120.0n' M='1'
  Mntrans123 CP2 CP1 inh_lSup inh_bulk_n NREG W='500n' L='120.0n' M='1'
  MN0 net158 RN inh_lSup inh_bulk_n NREG W='400n' L='120.0n' M='1'
  MN1 SB3 SF2 net158 inh_bulk_n NREG W='400n' L='120.0n' M='1'
  Mntrans153 net200 MB2 inh_lSup inh_bulk_n NREG W='500n' L='120.0n' M='1'
  MN3 SF2 CP2 MB2 inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  MN4 QN SF2 inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  Mptrans63 D1 D inh_hSup inh_bulk_p PREG W='1.2u' L='120.0n' M='1'
  Mptrans151 net153 RN inh_hSup inh_bulk_p PREG W='1u' L='120.0n' M='1'
  Mptrans118 CP1 CP inh_hSup inh_bulk_p PREG W='900n' L='120.0n' M='1'
  MP4 SF2 CP2 net105 inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP6 MF1 CP2 D1 inh_bulk_p PREG W='500n' L='120.0n' M='1'
  Mptrans127 MB2 MF1 inh_hSup inh_bulk_p PREG W='1.3u' L='120.0n' M='1'
  Mptrans152 net153 MB2 inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP1 SB3 SF2 inh_hSup inh_bulk_p PREG W='400n' L='120.0n' M='1'
  Mptrans122 CP2 CP1 inh_hSup inh_bulk_p PREG W='750.0n' L='120.0n' M='1'
  MP0 SB3 RN inh_hSup inh_bulk_p PREG W='400n' L='120.0n' M='1'
  Mptrans160 net105 SB3 inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  Mptrans150 MF1 CP1 net153 inh_bulk_p PREG W='880.0n' L='120.0n' M='1'
  MP3 SF2 CP1 MB2 inh_bulk_p PREG W='1.12u' L='120.0n' M='1'
  MP5 QN SF2 inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='1.98608e-11'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: EXORV
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT EXORV A B Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  MN6 net096 B net095 inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  Mntrans4 net32 A inh_lSup inh_bulk_n NREG W='3.36u' L='120.0n' M='1'
  Mntrans12 net082 B inh_lSup inh_bulk_n NREG W='800n' L='120.0n' M='1'
  MN5 net095 net32 inh_lSup inh_bulk_n NREG W='2.24u' L='120.0n' M='1'
  MN4 Z net096 inh_lSup inh_bulk_n NREG W='4.48u' L='120.0n' M='1'
  MN7 net096 net082 net32 inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  MP5 net095 net32 inh_hSup inh_bulk_p PREG W='3.24u' L='120.0n' M='1'
  MP7 net096 B net32 inh_bulk_p PREG W='1.12u' L='120.0n' M='1'
  Mptrans3 net32 A inh_hSup inh_bulk_p PREG W='4.86u' L='120.0n' M='1'
  Mptrans11 net082 B inh_hSup inh_bulk_p PREG W='1.12u' L='120.0n' M='1'
  MP6 net096 net082 net095 inh_bulk_p PREG W='1.12u' L='120.0n' M='1'
  MP4 Z net096 inh_hSup inh_bulk_p PREG W='6.48u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='1.6838e-11'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_serializer_data_mux
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_serializer_data_mux VDD VSS a0 a1 s z inh_bulk_n inh_bulk_p
  Mntrans1<2> net29<2> a0 VSS inh_bulk_n NREG W='2.72u' L='120.0n' M='1'
  Mntrans1<1> net29<1> a0 VSS inh_bulk_n NREG W='2.72u' L='120.0n' M='1'
  Mntrans1<0> net29<0> a0 VSS inh_bulk_n NREG W='2.72u' L='120.0n' M='1'
  Mntrans2<2> z net6 net27<2> inh_bulk_n NREG W='2.72u' L='120.0n' M='1'
  Mntrans2<1> z net6 net27<1> inh_bulk_n NREG W='2.72u' L='120.0n' M='1'
  Mntrans2<0> z net6 net27<0> inh_bulk_n NREG W='2.72u' L='120.0n' M='1'
  Mntrans3<2> net27<2> a1 VSS inh_bulk_n NREG W='2.72u' L='120.0n' M='1'
  Mntrans3<1> net27<1> a1 VSS inh_bulk_n NREG W='2.72u' L='120.0n' M='1'
  Mntrans3<0> net27<0> a1 VSS inh_bulk_n NREG W='2.72u' L='120.0n' M='1'
  Mntrans0<2> z net7 net29<2> inh_bulk_n NREG W='2.72u' L='120.0n' M='1'
  Mntrans0<1> z net7 net29<1> inh_bulk_n NREG W='2.72u' L='120.0n' M='1'
  Mntrans0<0> z net7 net29<0> inh_bulk_n NREG W='2.72u' L='120.0n' M='1'
  XI155 net6 net7 inh_bulk_n inh_bulk_p VDD VSS INV4
  XI156 net7 net6 inh_bulk_n inh_bulk_p VDD VSS INV4
  Mptrans2<2> net28<2> a1 VDD inh_bulk_p PREG W='6.16u' L='120.0n' M='1'
  Mptrans2<1> net28<1> a1 VDD inh_bulk_p PREG W='6.16u' L='120.0n' M='1'
  Mptrans2<0> net28<0> a1 VDD inh_bulk_p PREG W='6.16u' L='120.0n' M='1'
  Mptrans0<2> net30<2> a0 VDD inh_bulk_p PREG W='6.16u' L='120.0n' M='1'
  Mptrans0<1> net30<1> a0 VDD inh_bulk_p PREG W='6.16u' L='120.0n' M='1'
  Mptrans0<0> net30<0> a0 VDD inh_bulk_p PREG W='6.16u' L='120.0n' M='1'
  Mptrans1<2> z net6 net30<2> inh_bulk_p PREG W='6.16u' L='120.0n' M='1'
  Mptrans1<1> z net6 net30<1> inh_bulk_p PREG W='6.16u' L='120.0n' M='1'
  Mptrans1<0> z net6 net30<0> inh_bulk_p PREG W='6.16u' L='120.0n' M='1'
  Mptrans3<2> z net7 net28<2> inh_bulk_p PREG W='6.16u' L='120.0n' M='1'
  Mptrans3<1> z net7 net28<1> inh_bulk_p PREG W='6.16u' L='120.0n' M='1'
  Mptrans3<0> z net7 net28<0> inh_bulk_p PREG W='6.16u' L='120.0n' M='1'
  C33 z VSS C='5f'
  XI151 net31 s net7 inh_bulk_n inh_bulk_p VDD VSS EXORV
  XI154 net32 s net6 inh_bulk_n inh_bulk_p VDD VSS EXORV
  XI153 net32 inh_bulk_n inh_bulk_p VDD VSS TIEZERO
  XI152 net31 inh_bulk_n inh_bulk_p VDD VSS TIEONE
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_serializer
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_serializer VDD VSS clk_byte_o clk_i en_i hstx_data_i<15> hstx_data_i<14> hstx_data_i<13> hstx_data_i<12> hstx_data_i<11> hstx_data_i<10> hstx_data_i<9> hstx_data_i<8> hstx_data_i<7> hstx_data_i<6> hstx_data_i<5> hstx_data_i<4> hstx_data_i<3>
+ hstx_data_i<2> hstx_data_i<1> hstx_data_i<0> msb_first_en_i rstn_i ser_lb_n_o ser_p_o inh_bulk_n inh_bulk_p
  XI135 clk_div4_s net0112 clk_byte_o rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QB
  XI117 clk_div2_s net0209 clk_div4_s rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QB
  C7 d3<0> VSS C='10f'
  C12 net0125 VSS C='5f'
  C19 clk_div4_s VSS C='15f'
  C3 d2<2> VSS C='5f'
  C1 d3<0> VSS C='10f'
  C9 clk_byte_o VSS C='15f'
  C5 d2<1> VSS C='5f'
  C25 d2<3> VSS C='5f'
  C26 clk_s VSS C='10f'
  C27 clk_div2_s VSS C='15f'
  C8 d3<1> VSS C='5f'
  C35 clk_s VSS C='5f'
  C2 d2<0> VSS C='5f'
  XI145 ser_p_o ser_lb_n_o inh_bulk_n inh_bulk_p VDD VSS INV6
  XI159 net023 inh_bulk_n inh_bulk_p VDD VSS TIEZERO
  XI95 rstn_i en_i rstn_s inh_bulk_n inh_bulk_p VDD VSS AND2V
  XI118 clk_div4_s net0209 inh_bulk_n inh_bulk_p VDD VSS INV1
  XI136 clk_byte_o net0112 inh_bulk_n inh_bulk_p VDD VSS INV1
  XI53 clk_div2_s net0167 inh_bulk_n inh_bulk_p VDD VSS INV1
  XI167 clk_div2_s d1<0> d2<0> rstn_s clk_div4_s d1<4> inh_bulk_n inh_bulk_p VDD VSS FD2QNSP
  XI168 clk_div2_s d1<2> d2<2> rstn_s clk_div4_s d1<6> inh_bulk_n inh_bulk_p VDD VSS FD2QNSP
  XI170 clk_div2_s d1<3> d2<3> rstn_s clk_div4_s d1<7> inh_bulk_n inh_bulk_p VDD VSS FD2QNSP
  XI169 clk_div2_s d1<1> d2<1> rstn_s clk_div4_s d1<5> inh_bulk_n inh_bulk_p VDD VSS FD2QNSP
  XI148 VDD VSS net023 clk_i rstn_s clk_s inh_bulk_n inh_bulk_p phy_serializer_clkmux
  XI166 d2<0> d2<2> clk_div2_s net068 inh_bulk_n inh_bulk_p VDD VSS MXI2P
  XI163 d2<1> d2<3> clk_div2_s net069 inh_bulk_n inh_bulk_p VDD VSS MXI2P
  XI107 clk_div4_s d0<6> d1<6> rstn_s clk_byte_o d0<14> inh_bulk_n inh_bulk_p VDD VSS FD2QS
  XI105 clk_div4_s d0<2> d1<2> rstn_s clk_byte_o d0<10> inh_bulk_n inh_bulk_p VDD VSS FD2QS
  XI106 clk_div4_s d0<4> d1<4> rstn_s clk_byte_o d0<12> inh_bulk_n inh_bulk_p VDD VSS FD2QS
  XI108 clk_div4_s d0<0> d1<0> rstn_s clk_byte_o d0<8> inh_bulk_n inh_bulk_p VDD VSS FD2QS
  XI101 clk_div4_s d0<7> d1<7> rstn_s clk_byte_o d0<15> inh_bulk_n inh_bulk_p VDD VSS FD2QS
  XI102 clk_div4_s d0<3> d1<3> rstn_s clk_byte_o d0<11> inh_bulk_n inh_bulk_p VDD VSS FD2QS
  XI126<15> clk_byte_o hstx_data_i<0> d0<15> rstn_s msb_first_en_i hstx_data_i<15> inh_bulk_n inh_bulk_p VDD VSS FD2QS
  XI126<14> clk_byte_o hstx_data_i<1> d0<14> rstn_s msb_first_en_i hstx_data_i<14> inh_bulk_n inh_bulk_p VDD VSS FD2QS
  XI126<13> clk_byte_o hstx_data_i<2> d0<13> rstn_s msb_first_en_i hstx_data_i<13> inh_bulk_n inh_bulk_p VDD VSS FD2QS
  XI126<12> clk_byte_o hstx_data_i<3> d0<12> rstn_s msb_first_en_i hstx_data_i<12> inh_bulk_n inh_bulk_p VDD VSS FD2QS
  XI126<11> clk_byte_o hstx_data_i<4> d0<11> rstn_s msb_first_en_i hstx_data_i<11> inh_bulk_n inh_bulk_p VDD VSS FD2QS
  XI126<10> clk_byte_o hstx_data_i<5> d0<10> rstn_s msb_first_en_i hstx_data_i<10> inh_bulk_n inh_bulk_p VDD VSS FD2QS
  XI126<9> clk_byte_o hstx_data_i<6> d0<9> rstn_s msb_first_en_i hstx_data_i<9> inh_bulk_n inh_bulk_p VDD VSS FD2QS
  XI126<8> clk_byte_o hstx_data_i<7> d0<8> rstn_s msb_first_en_i hstx_data_i<8> inh_bulk_n inh_bulk_p VDD VSS FD2QS
  XI126<7> clk_byte_o hstx_data_i<8> d0<7> rstn_s msb_first_en_i hstx_data_i<7> inh_bulk_n inh_bulk_p VDD VSS FD2QS
  XI126<6> clk_byte_o hstx_data_i<9> d0<6> rstn_s msb_first_en_i hstx_data_i<6> inh_bulk_n inh_bulk_p VDD VSS FD2QS
  XI126<5> clk_byte_o hstx_data_i<10> d0<5> rstn_s msb_first_en_i hstx_data_i<5> inh_bulk_n inh_bulk_p VDD VSS FD2QS
  XI126<4> clk_byte_o hstx_data_i<11> d0<4> rstn_s msb_first_en_i hstx_data_i<4> inh_bulk_n inh_bulk_p VDD VSS FD2QS
  XI126<3> clk_byte_o hstx_data_i<12> d0<3> rstn_s msb_first_en_i hstx_data_i<3> inh_bulk_n inh_bulk_p VDD VSS FD2QS
  XI126<2> clk_byte_o hstx_data_i<13> d0<2> rstn_s msb_first_en_i hstx_data_i<2> inh_bulk_n inh_bulk_p VDD VSS FD2QS
  XI126<1> clk_byte_o hstx_data_i<14> d0<1> rstn_s msb_first_en_i hstx_data_i<1> inh_bulk_n inh_bulk_p VDD VSS FD2QS
  XI126<0> clk_byte_o hstx_data_i<15> d0<0> rstn_s msb_first_en_i hstx_data_i<0> inh_bulk_n inh_bulk_p VDD VSS FD2QS
  XI103 clk_div4_s d0<1> d1<1> rstn_s clk_byte_o d0<9> inh_bulk_n inh_bulk_p VDD VSS FD2QS
  XI104 clk_div4_s d0<5> d1<5> rstn_s clk_byte_o d0<13> inh_bulk_n inh_bulk_p VDD VSS FD2QS
  XI65 net0125 clk_s d3<1> rstn_s inh_bulk_n inh_bulk_p VDD VSS DP2NQH
  XI165 clk_s net068 net0125 rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QNP
  XI164 clk_s net069 d3<0> rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QNP
  XI158 VDD VSS d3<0> d3<1> clk_s ser_p_o inh_bulk_n inh_bulk_p phy_serializer_data_mux
  XI10 clk_s net0167 clk_div2_s rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QV
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: BUF3
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT BUF3 A Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mptrans15 net24 A inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  Mptrans14 Z net24 inh_hSup inh_bulk_p PREG W='2.44u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='5.4e-12'
  Mntrans13 net24 A inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  Mntrans12 Z net24 inh_lSup inh_bulk_n NREG W='1.7u' L='120.0n' M='1'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: FD2QP
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT FD2QP CP D Q RN inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mntrans65 D1 D inh_lSup inh_bulk_n NREG W='560.0n' L='120.0n' M='1'
  Mntrans158 SF2 CP1 net206 inh_bulk_n NREG W='400n' L='120.0n' M='1'
  Mntrans128 MB2 MF1 inh_lSup inh_bulk_n NREG W='700n' L='120.0n' M='1'
  MN5 MF1 CP1 D1 inh_bulk_n NREG W='400n' L='120.0n' M='1'
  Mntrans156 net206 SB3 inh_lSup inh_bulk_n NREG W='400n' L='120.0n' M='1'
  Mntrans119 CP1 CP inh_lSup inh_bulk_n NREG W='560.0n' L='120.0n' M='1'
  Mntrans155 net188 RN net200 inh_bulk_n NREG W='500n' L='120.0n' M='1'
  Mntrans154 MF1 CP2 net188 inh_bulk_n NREG W='500n' L='120.0n' M='1'
  Mntrans123 CP2 CP1 inh_lSup inh_bulk_n NREG W='460.0n' L='120.0n' M='1'
  MN0 net158 RN inh_lSup inh_bulk_n NREG W='1u' L='120.0n' M='1'
  MN1 SB3 SF2 net158 inh_bulk_n NREG W='1u' L='120.0n' M='1'
  Mntrans153 net200 MB2 inh_lSup inh_bulk_n NREG W='500n' L='120.0n' M='1'
  MN3 SF2 CP2 MB2 inh_bulk_n NREG W='800n' L='120.0n' M='1'
  MN4 Q SB3 inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  Mptrans63 D1 D inh_hSup inh_bulk_p PREG W='800n' L='120.0n' M='1'
  Mptrans151 net153 RN inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  Mptrans118 CP1 CP inh_hSup inh_bulk_p PREG W='800n' L='120.0n' M='1'
  MP4 SF2 CP2 net105 inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP6 MF1 CP2 D1 inh_bulk_p PREG W='400n' L='120.0n' M='1'
  Mptrans127 MB2 MF1 inh_hSup inh_bulk_p PREG W='1u' L='120.0n' M='1'
  Mptrans152 net153 MB2 inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP1 SB3 SF2 inh_hSup inh_bulk_p PREG W='1.2u' L='120.0n' M='1'
  Mptrans122 CP2 CP1 inh_hSup inh_bulk_p PREG W='660.0n' L='120.0n' M='1'
  MP0 SB3 RN inh_hSup inh_bulk_p PREG W='1.2u' L='120.0n' M='1'
  Mptrans160 net105 SB3 inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  Mptrans150 MF1 CP1 net153 inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP3 SF2 CP1 MB2 inh_bulk_p PREG W='800n' L='120.0n' M='1'
  MP5 Q SB3 inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='1.98e-11'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: MX2P
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT MX2P A0 A1 S Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  MP0 net101 A0 inh_hSup inh_bulk_p PREG W='1.28u' L='120.0n' M='1'
  MP3 net62 net79 net59 inh_bulk_p PREG W='700n' L='120.0n' M='1'
  MP2 net62 S net101 inh_bulk_p PREG W='700n' L='120.0n' M='1'
  Mptrans74 net79 S inh_hSup inh_bulk_p PREG W='750.0n' L='120.0n' M='1'
  MP1 net59 A1 inh_hSup inh_bulk_p PREG W='1.28u' L='120.0n' M='1'
  Mptrans68 Z net62 inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  Mntrans73 net79 S inh_lSup inh_bulk_n NREG W='500n' L='120.0n' M='1'
  MN3 net62 S net59 inh_bulk_n NREG W='700n' L='120.0n' M='1'
  MN2 net62 net79 net101 inh_bulk_n NREG W='700n' L='120.0n' M='1'
  MN1 net59 A1 inh_lSup inh_bulk_n NREG W='900n' L='120.0n' M='1'
  MN0 net101 A0 inh_lSup inh_bulk_n NREG W='900n' L='120.0n' M='1'
  Mntrans70 Z net62 inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='9e-12'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: NAND2V
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT NAND2V A B Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  MN3 Z A net37 inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  MN2 net37 B inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  MN1 net40 B inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  MN0 Z A net40 inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  Mntrans35 Z A net49 inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  Mntrans36 net49 B inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  MN4 net52 B inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  MN5 Z A net52 inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  Mptrans37 Z A inh_hSup inh_bulk_p PREG W='6.48u' L='120.0n' M='1'
  Mptrans38 Z B inh_hSup inh_bulk_p PREG W='6.48u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='9.9e-12'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: FDN2QNP
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT FDN2QNP CP D QN RN inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mntrans65 D1 D inh_lSup inh_bulk_n NREG W='800n' L='120.0n' M='1'
  Mntrans158 SF2 CP2 net206 inh_bulk_n NREG W='400n' L='120.0n' M='1'
  Mntrans128 MB2 MF1 inh_lSup inh_bulk_n NREG W='1u' L='120.0n' M='1'
  MN5 MF1 CP2 D1 inh_bulk_n NREG W='500n' L='120.0n' M='1'
  Mntrans156 net206 SB3 inh_lSup inh_bulk_n NREG W='400n' L='120.0n' M='1'
  Mntrans119 CP1 CP inh_lSup inh_bulk_n NREG W='650.0n' L='120.0n' M='1'
  Mntrans155 net0144 RN net200 inh_bulk_n NREG W='500n' L='120.0n' M='1'
  Mntrans154 net0144 CP1 MF1 inh_bulk_n NREG W='850.0n' L='120.0n' M='1'
  Mntrans123 CP2 CP1 inh_lSup inh_bulk_n NREG W='500n' L='120.0n' M='1'
  MN0 net158 RN inh_lSup inh_bulk_n NREG W='400n' L='120.0n' M='1'
  MN1 SB3 SF2 net158 inh_bulk_n NREG W='400n' L='120.0n' M='1'
  Mntrans153 net200 MB2 inh_lSup inh_bulk_n NREG W='500n' L='120.0n' M='1'
  MN3 SF2 CP1 MB2 inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  MN4 QN SF2 inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  Mptrans63 D1 D inh_hSup inh_bulk_p PREG W='1.2u' L='120.0n' M='1'
  Mptrans151 net0144 RN inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  Mptrans118 CP1 CP inh_hSup inh_bulk_p PREG W='900n' L='120.0n' M='1'
  MP4 SF2 CP1 net105 inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP6 MF1 CP1 D1 inh_bulk_p PREG W='500n' L='120.0n' M='1'
  Mptrans127 MB2 MF1 inh_hSup inh_bulk_p PREG W='1.3u' L='120.0n' M='1'
  Mptrans152 net0144 MB2 inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  MP1 SB3 SF2 inh_hSup inh_bulk_p PREG W='400n' L='120.0n' M='1'
  Mptrans122 CP2 CP1 inh_hSup inh_bulk_p PREG W='750.0n' L='120.0n' M='1'
  MP0 SB3 RN inh_hSup inh_bulk_p PREG W='400n' L='120.0n' M='1'
  Mptrans160 net105 SB3 inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  Mptrans150 net0144 CP2 MF1 inh_bulk_p PREG W='880.0n' L='120.0n' M='1'
  MP3 SF2 CP2 MB2 inh_bulk_p PREG W='1.12u' L='120.0n' M='1'
  MP5 QN SF2 inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='2.07e-11'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_hr_deser
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_hr_deser VDD VSS clk_n_i clk_p_i data_o<15> data_o<14> data_o<13> data_o<12> data_o<11> data_o<10> data_o<9> data_o<8> data_o<7> data_o<6> data_o<5> data_o<4> data_o<3> data_o<2> data_o<1> data_o<0> data_ser_i en_i rstn_i inh_bulk_n inh_bulk_p
  XI121 net029 clk_p_s inh_bulk_n inh_bulk_p VDD VSS BUF3
  XI122 net028 clk_n_s inh_bulk_n inh_bulk_p VDD VSS BUF3
  XI118 en_i rstn_i rstn_s inh_bulk_n inh_bulk_p VDD VSS AND2V
  XI116 net0105 net0135 data_o<11> rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI115 net0105 net0140 data_o<7> rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI114 net0105 net0141 data_o<5> rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI113 net0105 net0129 data_o<1> rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI112 net0105 net0127 data_o<3> rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI111 net0105 net0134 data_o<9> rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI110 net0105 net0136 data_o<13> rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI109 net0105 net0137 data_o<15> rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI108 net099 net0135 net0127 rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI107 net099 net0134 net0129 rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI106 net099 net0136 net0141 rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI105 net099 net0137 net0140 rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI104 clk180_250mhz_s net0130 net0128 rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI103 clk180_250mhz_s net0131 net0109 rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI102 clk180_250mhz_s net0116 net0126 rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI101 clk180_250mhz_s net0112 net0113 rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI100 net069 net0130 data_o<14> rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI99 net069 net0116 data_o<12> rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI98 net069 net0112 data_o<10> rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI60 clk180_250mhz_s data_e_500mbps_s net0130 rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI70 clk180_250mhz_s net040 net0131 rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI59 clk180_250mhz_s net042 net0116 rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI69 clk180_250mhz_s net041 net0112 rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI41 net099 net049 net0134 rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI40 net099 net050 net0135 rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI39 net099 net047 net0136 rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI31 net099 data_o_500mbps_s net0137 rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI24 clk_p_s data_ser_s data_o_1gbps_s rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI64 clk_n_s data_ser_s data_e_1gbps_s rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI67 clk180_500mhz_s net042 net040 rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI97 net069 net0131 data_o<8> rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI5 clk0_500mhz_s net073 net047 rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI4 clk0_500mhz_s data_o_1gbps_s data_o_500mbps_s rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI7 clk0_500mhz_s data_o_500mbps_s net050 rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI6 clk0_500mhz_s net047 net049 rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI96 net069 net0109 data_o<0> rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI94 net069 net0126 data_o<4> rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI62 clk180_500mhz_s data_e_1gbps_s data_e_500mbps_s rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI61 clk180_500mhz_s net025 net042 rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI68 clk180_500mhz_s data_e_500mbps_s net041 rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI1 clk_p_s data_o_1gbps_s net073 rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI65 clk_n_s data_e_1gbps_s net025 rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI90 net069 net0128 data_o<6> rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI95 net069 net0113 data_o<2> rstn_s inh_bulk_n inh_bulk_p VDD VSS FD2QP
  XI124 net079 inh_bulk_n inh_bulk_p VDD VSS TIEONE
  XI92 net079 clk_n_i rstn_s net028 inh_bulk_n inh_bulk_p VDD VSS MX2P
  XI87 net0111 clk_p_i rstn_s net029 inh_bulk_n inh_bulk_p VDD VSS MX2P
  XI120 data_ser_i en_i data_ser_s inh_bulk_n inh_bulk_p VDD VSS NAND2V
  XI55 clk0_500mhz_s net099 net099 rstn_s inh_bulk_n inh_bulk_p VDD VSS FDN2QNP
  XI46 clk_p_s clk0_500mhz_s clk0_500mhz_s rstn_s inh_bulk_n inh_bulk_p VDD VSS FDN2QNP
  XI89 clk180_250mhz_s net069 net069 rstn_s inh_bulk_n inh_bulk_p VDD VSS FDN2QNP
  XI63 clk180_500mhz_s clk180_250mhz_s clk180_250mhz_s rstn_s inh_bulk_n inh_bulk_p VDD VSS FDN2QNP
  XI66 clk_n_s clk180_500mhz_s clk180_500mhz_s rstn_s inh_bulk_n inh_bulk_p VDD VSS FDN2QNP
  XI88 net099 net0105 net0105 rstn_s inh_bulk_n inh_bulk_p VDD VSS FDN2QNP
  XI123 net0111 inh_bulk_n inh_bulk_p VDD VSS TIEZERO
  C102 net0134 VSS C='5f'
  C101 net0135 VSS C='5f'
  C100 net0137 VSS C='5f'
  C99 net0136 VSS C='5f'
  C98 net0131 VSS C='5f'
  C97 net0116 VSS C='5f'
  C96 net0130 VSS C='5f'
  C95 net0112 VSS C='5f'
  C63 net050 VSS C='5f'
  C86 net0109 VSS C='5f'
  C78 net041 VSS C='5f'
  C85 net040 VSS C='5f'
  C77 net0126 VSS C='5f'
  C65 net0129 VSS C='5f'
  C66 net0127 VSS C='5f'
  C68 net0140 VSS C='5f'
  C67 net0141 VSS C='5f'
  C13 clk_p_s VSS C='10f'
  C76 net0128 VSS C='5f'
  C75 net0113 VSS C='5f'
  C60 net073 VSS C='5f'
  C88 data_ser_s VSS C='10f'
  C9 rstn_s VSS C='30f'
  C84 clk180_500mhz_s VSS C='5f'
  C59 data_o_1gbps_s VSS C='5f'
  C62 net047 VSS C='5f'
  C7 clk0_500mhz_s VSS C='5f'
  C90 clk_n_s VSS C='10f'
  C92 net0105 VSS C='15f'
  C109 net028 VSS C='3f'
  C83 data_e_1gbps_s VSS C='5f'
  C82 net025 VSS C='5f'
  C81 clk180_250mhz_s VSS C='15f'
  C80 data_e_500mbps_s VSS C='5f'
  C79 net042 VSS C='5f'
  C64 net049 VSS C='5f'
  C58 net099 VSS C='15f'
  C61 data_o_500mbps_s VSS C='5f'
  C108 net029 VSS C='3f'
  C94 net069 VSS C='15f'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_hstx_metal_res
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_hstx_metal_res VSS a b
  R0 b a R='106.5m'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_hstx_ldo_new_v2
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_hstx_ldo_new_v2 VDD VSS disable_res_i hstx_ldo_pd ibias1_10u_i ibias2_10u_i ldo_0v4 monitor_en_i monitor_vout_o vfb_i vref inh_bulk_n inh_bulk_p
  VIMess2 mirr_p net069 DC 0
  VIMess1 casc_p net063 DC 0
  MN0 VDD pd_gate ldo_0v4 inh_bulk_n NREG W='299.84u' L='150n' M='5'
  MN26 pd_gate hstx_ldo_pd VSS inh_bulk_n NANA W='680.0n' L='400n' M='1'
  MN21 net038 net033 VSS inh_bulk_n NREG W='10u' L='480.0n' M='1'
  MN6<1> left left VSS inh_bulk_n NANA W='6u' L='1u' M='1'
  MN6<0> left left VSS inh_bulk_n NANA W='6u' L='1u' M='1'
  MN9 casc_n net053 ibias2_10u_i inh_bulk_n NANA W='680.0n' L='400n' M='1'
  MN4 pd_gate right VSS inh_bulk_n NANA W='24.0u' L='1u' M='1'
  MN28 ibias2_10u_i casc_n net051 inh_bulk_n NANA W='4u' L='3u' M='1'
  MN1<1> left right VSS inh_bulk_n NANA W='2.2u' L='1u' M='1'
  MN1<0> left right VSS inh_bulk_n NANA W='2.2u' L='1u' M='1'
  MN5 top left VSS inh_bulk_n NANA W='24.0u' L='1u' M='1'
  MN27 net051 casc_n VSS inh_bulk_n NANA W='4u' L='3u' M='1'
  MN25 right hstx_ldo_pd VSS inh_bulk_n NANA W='680.0n' L='400n' M='1'
  MN24 left hstx_ldo_pd VSS inh_bulk_n NANA W='680.0n' L='400n' M='1'
  MN3<1> right right VSS inh_bulk_n NANA W='6u' L='1u' M='1'
  MN3<0> right right VSS inh_bulk_n NANA W='6u' L='1u' M='1'
  MN2<1> right left VSS inh_bulk_n NANA W='2.2u' L='1u' M='1'
  MN2<0> right left VSS inh_bulk_n NANA W='2.2u' L='1u' M='1'
  MN29 casc_n hstx_ldo_pd VSS inh_bulk_n NANA W='680.0n' L='400n' M='1'
  MN8 mirr_n net053 ibias1_10u_i inh_bulk_n NANA W='680.0n' L='400n' M='1'
  MN30 mirr_n hstx_ldo_pd VSS inh_bulk_n NANA W='680.0n' L='400n' M='1'
  MN39 vref_s net053 vref inh_bulk_n NANA W='1u' L='400n' M='1'
  MN38 vref_s hstx_ldo_pd VSS inh_bulk_n NANA W='680.0n' L='400n' M='1'
  MN37 monitor_vout_o net052 VSS inh_bulk_n NANA W='680.0n' L='400n' M='1'
  MN36 monitor_vout_o monitor_en_i ldo_0v4 inh_bulk_n NANA W='1u' L='400n' M='1'
  MN35 net052 monitor_en_i VSS inh_bulk_n NANA W='680.0n' L='400n' M='1'
  MN34 net033 disable_res_i VSS inh_bulk_n NANA W='680.0n' L='400n' M='1'
  MN31 net053 hstx_ldo_pd VSS inh_bulk_n NANA W='680.0n' L='400n' M='1'
  XI40<19> VDD source casc_p mirr_p inh_bulk_p phy_bias_distributor_pmirr
  XI40<18> VDD source casc_p mirr_p inh_bulk_p phy_bias_distributor_pmirr
  XI40<17> VDD source casc_p mirr_p inh_bulk_p phy_bias_distributor_pmirr
  XI40<16> VDD source casc_p mirr_p inh_bulk_p phy_bias_distributor_pmirr
  XI40<15> VDD source casc_p mirr_p inh_bulk_p phy_bias_distributor_pmirr
  XI40<14> VDD source casc_p mirr_p inh_bulk_p phy_bias_distributor_pmirr
  XI40<13> VDD source casc_p mirr_p inh_bulk_p phy_bias_distributor_pmirr
  XI40<12> VDD source casc_p mirr_p inh_bulk_p phy_bias_distributor_pmirr
  XI40<11> VDD source casc_p mirr_p inh_bulk_p phy_bias_distributor_pmirr
  XI40<10> VDD source casc_p mirr_p inh_bulk_p phy_bias_distributor_pmirr
  XI40<9> VDD source casc_p mirr_p inh_bulk_p phy_bias_distributor_pmirr
  XI40<8> VDD source casc_p mirr_p inh_bulk_p phy_bias_distributor_pmirr
  XI40<7> VDD source casc_p mirr_p inh_bulk_p phy_bias_distributor_pmirr
  XI40<6> VDD source casc_p mirr_p inh_bulk_p phy_bias_distributor_pmirr
  XI40<5> VDD source casc_p mirr_p inh_bulk_p phy_bias_distributor_pmirr
  XI40<4> VDD source casc_p mirr_p inh_bulk_p phy_bias_distributor_pmirr
  XI40<3> VDD source casc_p mirr_p inh_bulk_p phy_bias_distributor_pmirr
  XI40<2> VDD source casc_p mirr_p inh_bulk_p phy_bias_distributor_pmirr
  XI40<1> VDD source casc_p mirr_p inh_bulk_p phy_bias_distributor_pmirr
  XI40<0> VDD source casc_p mirr_p inh_bulk_p phy_bias_distributor_pmirr
  XI17<1> VDD mirr_p casc_p mirr_p inh_bulk_p phy_bias_distributor_pmirr
  XI17<0> VDD mirr_p casc_p mirr_p inh_bulk_p phy_bias_distributor_pmirr
  R0 net038 ldo_0v4 R='200'
  XI68<27> VSS pd_gate VSS phy_ncap_200f
  XI68<26> VSS pd_gate VSS phy_ncap_200f
  XI68<25> VSS pd_gate VSS phy_ncap_200f
  XI68<24> VSS pd_gate VSS phy_ncap_200f
  XI68<23> VSS pd_gate VSS phy_ncap_200f
  XI68<22> VSS pd_gate VSS phy_ncap_200f
  XI68<21> VSS pd_gate VSS phy_ncap_200f
  XI68<20> VSS pd_gate VSS phy_ncap_200f
  XI68<19> VSS pd_gate VSS phy_ncap_200f
  XI68<18> VSS pd_gate VSS phy_ncap_200f
  XI68<17> VSS pd_gate VSS phy_ncap_200f
  XI68<16> VSS pd_gate VSS phy_ncap_200f
  XI68<15> VSS pd_gate VSS phy_ncap_200f
  XI68<14> VSS pd_gate VSS phy_ncap_200f
  XI68<13> VSS pd_gate VSS phy_ncap_200f
  XI68<12> VSS pd_gate VSS phy_ncap_200f
  XI68<11> VSS pd_gate VSS phy_ncap_200f
  XI68<10> VSS pd_gate VSS phy_ncap_200f
  XI68<9> VSS pd_gate VSS phy_ncap_200f
  XI68<8> VSS pd_gate VSS phy_ncap_200f
  XI68<7> VSS pd_gate VSS phy_ncap_200f
  XI68<6> VSS pd_gate VSS phy_ncap_200f
  XI68<5> VSS pd_gate VSS phy_ncap_200f
  XI68<4> VSS pd_gate VSS phy_ncap_200f
  XI68<3> VSS pd_gate VSS phy_ncap_200f
  XI68<2> VSS pd_gate VSS phy_ncap_200f
  XI68<1> VSS pd_gate VSS phy_ncap_200f
  XI69<10> VSS ldo_0v4 VSS phy_ncap_200f
  XI69<9> VSS ldo_0v4 VSS phy_ncap_200f
  XI69<8> VSS ldo_0v4 VSS phy_ncap_200f
  XI69<7> VSS ldo_0v4 VSS phy_ncap_200f
  XI69<6> VSS ldo_0v4 VSS phy_ncap_200f
  XI69<5> VSS ldo_0v4 VSS phy_ncap_200f
  XI69<4> VSS ldo_0v4 VSS phy_ncap_200f
  XI69<3> VSS ldo_0v4 VSS phy_ncap_200f
  XI69<2> VSS ldo_0v4 VSS phy_ncap_200f
  XI69<1> VSS ldo_0v4 VSS phy_ncap_200f
  MP3 top top VDD inh_bulk_p PANA W='74.88u' L='1u' M='1'
  MP16<1> net081<1> casc_p VDD inh_bulk_p PANA W='2.4u' L='2u' M='1'
  MP16<0> net081<0> casc_p VDD inh_bulk_p PANA W='2.4u' L='2u' M='1'
  MP17<1> casc_p casc_p net081<1> inh_bulk_p PANA W='2.4u' L='2u' M='1'
  MP17<0> casc_p casc_p net081<0> inh_bulk_p PANA W='2.4u' L='2u' M='1'
  MP2 pd_gate top VDD inh_bulk_p PANA W='74.88u' L='1u' M='1'
  MP15 vref_s hstx_ldo_pd vref inh_bulk_p PANA W='1u' L='400n' M='1'
  MP14 monitor_vout_o net052 ldo_0v4 inh_bulk_p PANA W='1u' L='400n' M='1'
  MP13 net052 monitor_en_i VDD inh_bulk_p PANA W='680.0n' L='400n' M='1'
  MP12 net033 disable_res_i VDD inh_bulk_p PANA W='680.0n' L='400n' M='1'
  MP11 top net053 VDD inh_bulk_p PANA W='680.0n' L='400n' M='1'
  MP10 casc_p net053 VDD inh_bulk_p PANA W='680.0n' L='400n' M='1'
  MP9 mirr_p net053 VDD inh_bulk_p PANA W='680.0n' L='400n' M='1'
  MP7 casc_n hstx_ldo_pd ibias2_10u_i inh_bulk_p PANA W='680.0n' L='400n' M='1'
  MP6 net053 hstx_ldo_pd VDD inh_bulk_p PANA W='680.0n' L='400n' M='1'
  MP8 mirr_n hstx_ldo_pd ibias1_10u_i inh_bulk_p PANA W='680.0n' L='400n' M='1'
  XI14 VSS ibias1_10u_i casc_n mirr_n inh_bulk_n phy_bias_distributor_nmirr
  XI13 VSS net063 casc_n mirr_n inh_bulk_n phy_bias_distributor_nmirr
  XI12 VSS net069 casc_n mirr_n inh_bulk_n phy_bias_distributor_nmirr
  MP0<1> left vfb_i source source PANA W='25.0u' L='400n' M='1'
  MP0<0> left vfb_i source source PANA W='25.0u' L='400n' M='1'
  MP1<1> right vref_s source source PANA W='25.0u' L='400n' M='1'
  MP1<0> right vref_s source source PANA W='25.0u' L='400n' M='1'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_hstx_ocd_v2
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_hstx_ocd_v2 VDD VSS n_l_i n_r_sel_1 n_r_sel_2 n_r_sel_4 n_u_i p_l_i p_r_sel_1 p_r_sel_2 p_r_sel_4 p_u_i pad_n pad_p vbias_0v4 inh_bulk_n
  C_f_VSS f VSS C='9.3f'
  C_a_VSS a VSS C='12.6f'
  C_d_VSS d VSS C='12.6f'
  C_c_VDD c VDD C='57.0e-18'
  C_f_VDD f VDD C='57.0e-18'
  C_drain_node_VSS drain_node VSS C='123.2f'
  C_source_node_VSS source_node VSS C='105.9f'
  C_c_VSS c VSS C='9.2f'
  C_b_VSS b VSS C='12.3f'
  C_e_VSS e VSS C='12.3f'
  C_b_VDD b VDD C='30e-18'
  C_e_VDD e VDD C='30.2e-18'
  C_source_node_VDD source_node VDD C='8.7f'
  C_drain_node_VDD drain_node VDD C='3.6f'
  R0 VSS source_node R='37.44'
  R1 vbias_0v4 drain_node R='40.6'
  R3<1> a drain_node R='497.5'
  R3<2> a drain_node R='497.5'
  R3<3> a drain_node R='497.5'
  R3<4> a drain_node R='497.5'
  R5<1> b drain_node R='497.5'
  R5<2> b drain_node R='497.5'
  R6 c drain_node R='497.5'
  R25 f source_node R='497.5'
  R26<1> e source_node R='497.5'
  R26<2> e source_node R='497.5'
  R28<1> d source_node R='497.5'
  R28<2> d source_node R='497.5'
  R28<3> d source_node R='497.5'
  R28<4> d source_node R='497.5'
  MN15 pad_n n_u_i drain_node inh_bulk_n NANA W='6.11u' L='150n' M='18'
  MN3<1> vbias_0v4 p_r_sel_4 a inh_bulk_n NREG W='5u' L='120.0n' M='1'
  MN3<2> vbias_0v4 p_r_sel_4 a inh_bulk_n NREG W='5u' L='120.0n' M='1'
  MN3<3> vbias_0v4 p_r_sel_4 a inh_bulk_n NREG W='5u' L='120.0n' M='1'
  MN3<4> vbias_0v4 p_r_sel_4 a inh_bulk_n NREG W='5u' L='120.0n' M='1'
  MN5<1> vbias_0v4 p_r_sel_2 b inh_bulk_n NREG W='5u' L='120.0n' M='1'
  MN5<2> vbias_0v4 p_r_sel_2 b inh_bulk_n NREG W='5u' L='120.0n' M='1'
  MN6 vbias_0v4 p_r_sel_1 c inh_bulk_n NREG W='5u' L='120.0n' M='1'
  M1 pad_p n_l_i source_node inh_bulk_n NANA W='5u' L='150n' M='18'
  M0 pad_n p_l_i source_node inh_bulk_n NANA W='5u' L='150n' M='18'
  MN7 pad_p p_u_i drain_node inh_bulk_n NANA W='6.11u' L='150n' M='18'
  MN25 VSS n_r_sel_1 f inh_bulk_n NREG W='5u' L='120.0n' M='1'
  MN26<1> VSS n_r_sel_2 e inh_bulk_n NREG W='5u' L='120.0n' M='1'
  MN26<2> VSS n_r_sel_2 e inh_bulk_n NREG W='5u' L='120.0n' M='1'
  MN28<1> VSS n_r_sel_4 d inh_bulk_n NREG W='5u' L='120.0n' M='1'
  MN28<2> VSS n_r_sel_4 d inh_bulk_n NREG W='5u' L='120.0n' M='1'
  MN28<3> VSS n_r_sel_4 d inh_bulk_n NREG W='5u' L='120.0n' M='1'
  MN28<4> VSS n_r_sel_4 d inh_bulk_n NREG W='5u' L='120.0n' M='1'
  C1 p_u_i VSS C='40f'
  C0 pad_p VSS C='40f'
  C3 n_u_i VSS C='40f'
  C5 vbias_0v4 VSS C='30f'
  C2 p_l_i VSS C='30f'
  C7 VDD VSS C='60f'
  C12 pad_n VSS C='40f'
  C6 VSS VSS C='565f'
  C4 n_l_i VSS C='30f'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: INV16
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT INV16 A Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mptrans10 Z A inh_hSup inh_bulk_p PREG W='12.96u' L='120.0n' M='1'
  Mntrans11 Z A inh_lSup inh_bulk_n NREG W='8.96u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='9.9e-12'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: AND2IP
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT AND2IP A B Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mptrans17 Z net35 net44 inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  Mptrans16 net44 A inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  Mptrans10 net35 B inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  MP1 Z net35 net59 inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  MP0 net59 A inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  Mntrans19 Z net35 inh_lSup inh_bulk_n NREG W='2.24u' L='120.0n' M='1'
  Mntrans18 Z A inh_lSup inh_bulk_n NREG W='2.24u' L='120.0n' M='1'
  Mntrans11 net35 B inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='7.2e-12'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: INV8
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT INV8 A Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mptrans10 Z A inh_hSup inh_bulk_p PREG W='6.48u' L='120.0n' M='1'
  Mntrans11 Z A inh_lSup inh_bulk_n NREG W='4.48u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='5.4e-12'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: NOR3B
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT NOR3B A B C Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mptrans21 Z A net37 inh_bulk_p PREG W='1.6u' L='120.0n' M='1'
  Mptrans20 net37 B net34 inh_bulk_p PREG W='1.6u' L='120.0n' M='1'
  Mptrans19 net34 C inh_hSup inh_bulk_p PREG W='1.6u' L='120.0n' M='1'
  MP2 Z A net031 inh_bulk_p PREG W='1.6u' L='120.0n' M='1'
  MP1 net031 B net034 inh_bulk_p PREG W='1.6u' L='120.0n' M='1'
  MP0 net034 C inh_hSup inh_bulk_p PREG W='1.6u' L='120.0n' M='1'
  MP8 Z A net045 inh_bulk_p PREG W='1.6u' L='120.0n' M='1'
  MP7 net045 B net048 inh_bulk_p PREG W='1.6u' L='120.0n' M='1'
  MP6 net048 C inh_hSup inh_bulk_p PREG W='1.6u' L='120.0n' M='1'
  MP5 Z A net054 inh_bulk_p PREG W='1.6u' L='120.0n' M='1'
  MP4 net054 B net057 inh_bulk_p PREG W='1.6u' L='120.0n' M='1'
  MP3 net057 C inh_hSup inh_bulk_p PREG W='1.6u' L='120.0n' M='1'
  Mntrans24 Z A inh_lSup inh_bulk_n NREG W='2.24u' L='120.0n' M='1'
  Mntrans23 Z B inh_lSup inh_bulk_n NREG W='2.24u' L='120.0n' M='1'
  Mntrans22 Z C inh_lSup inh_bulk_n NREG W='2.24u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='1.26e-11'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_hstx_prdrv
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_hstx_prdrv VDD VSS dft_ser_test_in_en dft_ser_test_n_i dft_ser_test_p_i en_fast_trf_i hstx_prdrv_i hstx_prdrv_lower_en hstx_prdrv_upper_en n_l_o n_u_o p_l_o p_u_o inh_bulk_n inh_bulk_p
  MP42<1> VDD net085 VDD inh_bulk_p PREG W='1.36u' L='120.0n' M='1'
  MP42<0> VDD net085 VDD inh_bulk_p PREG W='1.36u' L='120.0n' M='1'
  MP24 net033 dft_p_s net057 inh_bulk_p PREG W='680.0n' L='120.0n' M='1'
  MP22 net057 dft_en_n_s VDD inh_bulk_p PREG W='680.0n' L='120.0n' M='1'
  MP21 net043 dft_n_s net053 inh_bulk_p PREG W='680.0n' L='120.0n' M='1'
  MP19 net047 dft_n_s net056 inh_bulk_p PREG W='680.0n' L='120.0n' M='1'
  MP14 net020 dft_p_s net044 inh_bulk_p PREG W='680.0n' L='120.0n' M='1'
  MP20 net056 dft_en_n_s VDD inh_bulk_p PREG W='680.0n' L='120.0n' M='1'
  MP18 net053 dft_en_n_s VDD inh_bulk_p PREG W='680.0n' L='120.0n' M='1'
  MP41<1> VDD net085 VDD inh_bulk_p PREG W='1.36u' L='120.0n' M='1'
  MP41<0> VDD net085 VDD inh_bulk_p PREG W='1.36u' L='120.0n' M='1'
  MP35<4> net020 net085 net0121 inh_bulk_p PREG W='680n' L='120.0n' M='3'
  MP35<3> net020 net085 net0121 inh_bulk_p PREG W='680n' L='120.0n' M='3'
  MP35<2> net020 net085 net0121 inh_bulk_p PREG W='680n' L='120.0n' M='3'
  MP35<1> net020 net085 net0121 inh_bulk_p PREG W='680n' L='120.0n' M='3'
  MP35<0> net020 net085 net0121 inh_bulk_p PREG W='680n' L='120.0n' M='3'
  MP37<1> VDD net085 VDD inh_bulk_p PREG W='1.36u' L='120.0n' M='1'
  MP37<0> VDD net085 VDD inh_bulk_p PREG W='1.36u' L='120.0n' M='1'
  MP34<4> net043 net085 net0127 inh_bulk_p PREG W='680n' L='120.0n' M='3'
  MP34<3> net043 net085 net0127 inh_bulk_p PREG W='680n' L='120.0n' M='3'
  MP34<2> net043 net085 net0127 inh_bulk_p PREG W='680n' L='120.0n' M='3'
  MP34<1> net043 net085 net0127 inh_bulk_p PREG W='680n' L='120.0n' M='3'
  MP34<0> net043 net085 net0127 inh_bulk_p PREG W='680n' L='120.0n' M='3'
  MP30 net073 en_upper_n_s VDD inh_bulk_p PREG W='24.0u' L='120.0n' M='4'
  MP31 net043 d net073 inh_bulk_p PREG W='24.0u' L='120.0n' M='4'
  MP29 net068 en_lower_n_s VDD inh_bulk_p PREG W='24.0u' L='120.0n' M='4'
  MP15 net044 dft_en_n_s VDD inh_bulk_p PREG W='680.0n' L='120.0n' M='1'
  MP40<1> VDD net085 VDD inh_bulk_p PREG W='1.36u' L='120.0n' M='1'
  MP40<0> VDD net085 VDD inh_bulk_p PREG W='1.36u' L='120.0n' M='1'
  MP27 net033 c net075 inh_bulk_p PREG W='24.0u' L='120.0n' M='4'
  MP26 net075 en_lower_n_s VDD inh_bulk_p PREG W='24.0u' L='120.0n' M='4'
  MP25 net020 c net071 inh_bulk_p PREG W='24.0u' L='120.0n' M='4'
  MP28 net047 d net068 inh_bulk_p PREG W='24.0u' L='120.0n' M='4'
  MP33 net047 net085 net093 inh_bulk_p PREG W='680n' L='120.0n' M='3'
  MP32 net033 net085 net097 inh_bulk_p PREG W='680n' L='120.0n' M='3'
  MP10 net071 en_upper_n_s VDD inh_bulk_p PREG W='24.0u' L='120.0n' M='4'
  C17 c VSS C='5f'
  C16 d VSS C='5f'
  C15 b VSS C='5f'
  C14 a VSS C='5f'
  R15 n_l_o net096 R='700' M='1'
  R10 net096 net093 R='700' M='1'
  R12 p_u_o net099 R='700' M='1'
  R8 net0128 net0127 R='700' M='1'
  R7 net099 net0121 R='700' M='1'
  R13 p_l_o net098 R='700' M='1'
  R14 n_u_o net0128 R='700' M='1'
  R2 n_l_o net047 R='700'
  R1 p_u_o net020 R='700'
  R4 net098 net097 R='700' M='1'
  R3 n_u_o net043 R='700'
  R0 p_l_o net033 R='700'
  MN45<1> VSS net086 VSS inh_bulk_n NREG W='1.36u' L='120.0n' M='1'
  MN45<0> VSS net086 VSS inh_bulk_n NREG W='1.36u' L='120.0n' M='1'
  MN44<1> VSS net086 VSS inh_bulk_n NREG W='1.36u' L='120.0n' M='1'
  MN44<0> VSS net086 VSS inh_bulk_n NREG W='1.36u' L='120.0n' M='1'
  MN27 net043 power_down_s VSS inh_bulk_n NREG W='680.0n' L='120.0n' M='1'
  MN26 net047 power_down_s VSS inh_bulk_n NREG W='680.0n' L='120.0n' M='1'
  MN23 net033 power_down_s VSS inh_bulk_n NREG W='680.0n' L='120.0n' M='1'
  MN22 net020 power_down_s VSS inh_bulk_n NREG W='680.0n' L='120.0n' M='1'
  MN21 net090 dft_en_s VSS inh_bulk_n NREG W='680.0n' L='120.0n' M='1'
  MN14 net045 dft_en_s VSS inh_bulk_n NREG W='680.0n' L='120.0n' M='1'
  MN19 net043 dft_n_s net090 inh_bulk_n NREG W='680.0n' L='120.0n' M='1'
  MN18 net054 dft_en_s VSS inh_bulk_n NREG W='680.0n' L='120.0n' M='1'
  MN16 net033 dft_p_s net058 inh_bulk_n NREG W='680.0n' L='120.0n' M='1'
  MN20 net047 dft_n_s net054 inh_bulk_n NREG W='680.0n' L='120.0n' M='1'
  MN15 net020 dft_p_s net045 inh_bulk_n NREG W='680.0n' L='120.0n' M='1'
  MN17 net058 dft_en_s VSS inh_bulk_n NREG W='680.0n' L='120.0n' M='1'
  MN40<1> VSS net086 VSS inh_bulk_n NREG W='1.36u' L='120.0n' M='1'
  MN40<0> VSS net086 VSS inh_bulk_n NREG W='1.36u' L='120.0n' M='1'
  MN43<1> VSS net086 VSS inh_bulk_n NREG W='1.36u' L='120.0n' M='1'
  MN43<0> VSS net086 VSS inh_bulk_n NREG W='1.36u' L='120.0n' M='1'
  MN31 net043 d net072 inh_bulk_n NREG W='6.6u' L='120.0n' M='4'
  MN30 net033 c net074 inh_bulk_n NREG W='6.6u' L='120.0n' M='4'
  MN0 net074 en_lower_s VSS inh_bulk_n NREG W='6.6u' L='120.0n' M='4'
  MN28 net070 en_upper_s VSS inh_bulk_n NREG W='6.6u' L='120.0n' M='4'
  MN38<4> net0121 net086 net020 inh_bulk_n NREG W='680n' L='120.0n' M='1'
  MN38<3> net0121 net086 net020 inh_bulk_n NREG W='680n' L='120.0n' M='1'
  MN38<2> net0121 net086 net020 inh_bulk_n NREG W='680n' L='120.0n' M='1'
  MN38<1> net0121 net086 net020 inh_bulk_n NREG W='680n' L='120.0n' M='1'
  MN38<0> net0121 net086 net020 inh_bulk_n NREG W='680n' L='120.0n' M='1'
  MN37<4> net0127 net086 net043 inh_bulk_n NREG W='680n' L='120.0n' M='1'
  MN37<3> net0127 net086 net043 inh_bulk_n NREG W='680n' L='120.0n' M='1'
  MN37<2> net0127 net086 net043 inh_bulk_n NREG W='680n' L='120.0n' M='1'
  MN37<1> net0127 net086 net043 inh_bulk_n NREG W='680n' L='120.0n' M='1'
  MN37<0> net0127 net086 net043 inh_bulk_n NREG W='680n' L='120.0n' M='1'
  MN36 net093 net086 net047 inh_bulk_n NREG W='680n' L='120.0n' M='1'
  MN35 net097 net086 net033 inh_bulk_n NREG W='680n' L='120.0n' M='1'
  MN11 net020 c net070 inh_bulk_n NREG W='6.6u' L='120.0n' M='4'
  MN34 net047 d net069 inh_bulk_n NREG W='6.6u' L='120.0n' M='4'
  MN32 net072 en_upper_s VSS inh_bulk_n NREG W='6.6u' L='120.0n' M='4'
  MN33 net069 en_lower_s VSS inh_bulk_n NREG W='6.6u' L='120.0n' M='4'
  XI62 dft_en_n_s dft_en_s inh_bulk_n inh_bulk_p VDD VSS INV16
  XI61 dft_ser_test_in_en dft_en_n_s inh_bulk_n inh_bulk_p VDD VSS INV16
  XI25 b d inh_bulk_n inh_bulk_p VDD VSS INV16
  XI20 a c inh_bulk_n inh_bulk_p VDD VSS INV16
  XI51 dft_ser_test_in_en hstx_prdrv_lower_en en_lower_s inh_bulk_n inh_bulk_p VDD VSS AND2IP
  XI49 dft_ser_test_in_en hstx_prdrv_upper_en en_upper_s inh_bulk_n inh_bulk_p VDD VSS AND2IP
  C3 d net047 C='454.00e-18'
  C1 d net043 C='454.00e-18'
  C0 c net033 C='454.00e-18'
  C2 c net020 C='454.00e-18'
  XI22 net038 inh_bulk_n inh_bulk_p VDD VSS TIEONE
  XI23 net039 inh_bulk_n inh_bulk_p VDD VSS TIEZERO
  XI19 hstx_prdrv_i net038 a inh_bulk_n inh_bulk_p VDD VSS EXORV
  XI18 hstx_prdrv_i net039 b inh_bulk_n inh_bulk_p VDD VSS EXORV
  XI50 en_lower_s en_lower_n_s inh_bulk_n inh_bulk_p VDD VSS INV8
  XI28 c d inh_bulk_n inh_bulk_p VDD VSS INV8
  XI27 d c inh_bulk_n inh_bulk_p VDD VSS INV8
  XI70 net086 net085 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI39 en_upper_s en_upper_n_s inh_bulk_n inh_bulk_p VDD VSS INV8
  XI69 net095 net086 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI24 a b inh_bulk_n inh_bulk_p VDD VSS INV3
  XI21 b a inh_bulk_n inh_bulk_p VDD VSS INV3
  XI63 dft_ser_test_p_i dft_ser_test_in_en dft_p_s inh_bulk_n inh_bulk_p VDD VSS NAND2
  XI45 dft_ser_test_n_i dft_ser_test_in_en dft_n_s inh_bulk_n inh_bulk_p VDD VSS NAND2
  XI64 hstx_prdrv_lower_en hstx_prdrv_upper_en dft_ser_test_in_en power_down_s inh_bulk_n inh_bulk_p VDD VSS NOR3B
  XI71 en_fast_trf_i net095 inh_bulk_n inh_bulk_p VDD VSS INV4
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: A_CSAN2
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT A_CSAN2 A B Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mntrans22 Z net39 inh_lSup inh_bulk_n NANA W='740.0n' L='400n' M='1'
  Mntrans21 net39 A net32 inh_bulk_n NANA W='600n' L='400n' M='1'
  Mntrans20 net32 B inh_lSup inh_bulk_n NANA W='600n' L='400n' M='1'
  Mptrans25 Z net39 inh_hSup inh_bulk_p PANA W='1.1u' L='400n' M='1'
  Mptrans24 net39 A inh_hSup inh_bulk_p PANA W='600n' L='400n' M='1'
  Mptrans23 net39 B inh_hSup inh_bulk_p PANA W='600n' L='400n' M='1'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_hstx
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_hstx VDD VSS dft_ser_test_in_en dft_ser_test_n_i dft_ser_test_p_i dis_res_i en_fast_trf_i hstx_calib_lower_impedance<2> hstx_calib_lower_impedance<1> hstx_calib_lower_impedance<0> hstx_calib_upper_impedance<2> hstx_calib_upper_impedance<1>
+ hstx_calib_upper_impedance<0> hstx_en hstx_ldo_monitor_en_i hstx_ldo_monitor_vout_o hstx_ldo_vref hstx_lower_path_en hstx_n_i hstx_pwrdn ibias1_10u_i ibias2_10u_i pad_n pad_p inh_bulk_n inh_bulk_p
  XI1 VSS ldo_0v4_ss ldo_0v4_s phy_hstx_metal_res
  Xldo VDD VSS net35 hstx_pwrdn ibias1_10u_i ibias2_10u_i ldo_0v4_ss hstx_ldo_monitor_en_i hstx_ldo_monitor_vout_o ldo_0v4_s hstx_ldo_vref inh_bulk_n inh_bulk_p phy_hstx_ldo_new_v2
  Xocd VDD VSS n_l_s hstx_calib_lower_impedance<0> hstx_calib_lower_impedance<1> hstx_calib_lower_impedance<2> n_u_s p_l_s hstx_calib_upper_impedance<0> hstx_calib_upper_impedance<1> hstx_calib_upper_impedance<2> p_u_s pad_n pad_p ldo_0v4_ss inh_bulk_n
+ phy_hstx_ocd_v2
  Xprdrv VDD VSS dft_ser_test_in_en dft_ser_test_n_i dft_ser_test_p_i en_fast_trf_i hstx_n_i hstx_lower_path_en hstx_en n_l_s n_u_s p_l_s p_u_s inh_bulk_n inh_bulk_p phy_hstx_prdrv
  XI10 dis_res_i hstx_en net35 inh_bulk_n inh_bulk_p VDD VSS A_CSAN2
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_lane
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_lane VDD VSS bypass_delay_line_i clk_byte_o clk_n_i clk_p_i dft_hstx_data_loopback_o<15> dft_hstx_data_loopback_o<14> dft_hstx_data_loopback_o<13> dft_hstx_data_loopback_o<12> dft_hstx_data_loopback_o<11> dft_hstx_data_loopback_o<10>
+ dft_hstx_data_loopback_o<9> dft_hstx_data_loopback_o<8> dft_hstx_data_loopback_o<7> dft_hstx_data_loopback_o<6> dft_hstx_data_loopback_o<5> dft_hstx_data_loopback_o<4> dft_hstx_data_loopback_o<3> dft_hstx_data_loopback_o<2> dft_hstx_data_loopback_o<1>
+ dft_hstx_data_loopback_o<0> dft_hstx_ldo_monitor_en_i dft_hstx_ldo_monitor_vout_o dft_hstx_lower_path_en dft_lptx_ldo_monitor_en_i dft_lptx_ldo_monitor_vout_o dft_ser_test_in_en dft_ser_test_n_i dft_ser_test_p_i dis_res_i dphy_pwrdn_i dphy_reset_n_i
+ en_deserializer_i hs_ser_en_i hs_ser_msb_first_en_i hstx_calib_lower_impedance<2> hstx_calib_lower_impedance<1> hstx_calib_lower_impedance<0> hstx_calib_upper_impedance<2> hstx_calib_upper_impedance<1> hstx_calib_upper_impedance<0> hstx_data_i<15>
+ hstx_data_i<14> hstx_data_i<13> hstx_data_i<12> hstx_data_i<11> hstx_data_i<10> hstx_data_i<9> hstx_data_i<8> hstx_data_i<7> hstx_data_i<6> hstx_data_i<5> hstx_data_i<4> hstx_data_i<3> hstx_data_i<2> hstx_data_i<1> hstx_data_i<0> hstx_en_fast_trf_i
+ hstx_en_lptx_dis hstx_ldo_vref hstx_pwrdn ibias1_10u_i ibias2_10u_i lptx_dn lptx_dp lptx_en lptx_ldo_vref lptx_vref_prog<4> lptx_vref_prog<3> lptx_vref_prog<2> lptx_vref_prog<1> lptx_vref_prog<0> pad_n pad_p tx_delay_prog<2> tx_delay_prog<1> tx_delay_prog<0>
+ inh_bulk_n inh_bulk_p
  XI17 lptx_en_s hstx_pwrdn_s pwd_bias_s inh_bulk_n inh_bulk_p VDD VSS AND2I
  XI16 dphy_pwrdn_i lptx_en lptx_en_s inh_bulk_n inh_bulk_p VDD VSS AND2I
  XI18 dphy_pwrdn_i hstx_pwrdn hstx_pwrdn_s inh_bulk_n inh_bulk_p VDD VSS OR2
  Xlp_ldo VDD VSS net80 net80 net082 net081 ldo_1v2_s lptx_en_s dft_lptx_ldo_monitor_en_i dft_lptx_ldo_monitor_vout_o lptx_ldo_vref lptx_vref_prog<4> lptx_vref_prog<3> lptx_vref_prog<2> lptx_vref_prog<1> lptx_vref_prog<0> inh_bulk_n inh_bulk_p phy_lptx_ldo
  Xlptx_p VDD VSS lptx_dp lptx_en_s hstx_en_lptx_dis ibias4_10u_s<0> ldo_1v2_s pad_p_s inh_bulk_n inh_bulk_p phy_lptx
  Xlptx_n VDD VSS lptx_dn lptx_en_s hstx_en_lptx_dis ibias4_10u_s<1> ldo_1v2_s pad_n_s inh_bulk_n inh_bulk_p phy_lptx
  Xbias VDD VSS ibias1_10u_i ibias2_10u_i ibias1_25u_s ibias2_25u_s ibias3_10u_s ibias4_10u_s<1> ibias4_10u_s<0> pwd_bias_s ibias5_10u_s inh_bulk_n inh_bulk_p phy_bias_lane_distributor
  Xdelay VDD VSS bypass_delay_line_i data_ser_s data_dl_n_s tx_delay_prog<2> tx_delay_prog<1> tx_delay_prog<0> inh_bulk_n inh_bulk_p phy_prog_delay_line_with_bypass
  XI3 VDD VSS pad_p pad_p_s inh_bulk_n phy_esd_hf16diodes
  XI5 VDD VSS pad_n pad_n_s inh_bulk_n phy_esd_hf16diodes
  C8 ser_pn_s VSS C='5f'
  C1 data_ser_s VSS C='5f'
  C3 data_dl_n_s VSS C='5f'
  Xser VDD VSS clk_byte_o clk_p_i hs_ser_en_i hstx_data_i<15> hstx_data_i<14> hstx_data_i<13> hstx_data_i<12> hstx_data_i<11> hstx_data_i<10> hstx_data_i<9> hstx_data_i<8> hstx_data_i<7> hstx_data_i<6> hstx_data_i<5> hstx_data_i<4> hstx_data_i<3> hstx_data_i<2>
+ hstx_data_i<1> hstx_data_i<0> hs_ser_msb_first_en_i dphy_reset_n_i ser_pn_s data_ser_s inh_bulk_n inh_bulk_p phy_serializer
  XI14<425> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<424> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<423> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<422> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<421> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<420> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<419> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<418> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<417> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<416> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<415> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<414> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<413> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<412> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<411> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<410> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<409> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<408> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<407> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<406> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<405> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<404> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<403> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<402> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<401> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<400> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<399> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<398> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<397> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<396> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<395> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<394> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<393> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<392> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<391> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<390> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<389> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<388> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<387> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<386> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<385> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<384> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<383> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<382> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<381> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<380> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<379> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<378> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<377> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<376> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<375> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<374> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<373> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<372> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<371> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<370> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<369> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<368> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<367> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<366> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<365> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<364> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<363> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<362> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<361> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<360> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<359> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<358> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<357> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<356> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<355> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<354> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<353> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<352> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<351> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<350> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<349> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<348> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<347> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<346> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<345> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<344> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<343> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<342> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<341> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<340> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<339> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<338> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<337> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<336> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<335> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<334> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<333> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<332> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<331> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<330> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<329> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<328> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<327> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<326> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<325> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<324> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<323> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<322> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<321> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<320> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<319> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<318> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<317> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<316> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<315> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<314> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<313> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<312> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<311> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<310> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<309> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<308> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<307> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<306> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<305> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<304> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<303> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<302> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<301> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<300> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<299> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<298> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<297> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<296> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<295> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<294> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<293> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<292> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<291> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<290> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<289> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<288> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<287> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<286> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<285> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<284> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<283> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<282> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<281> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<280> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<279> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<278> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<277> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<276> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<275> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<274> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<273> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<272> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<271> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<270> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<269> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<268> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<267> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<266> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<265> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<264> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<263> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<262> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<261> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<260> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<259> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<258> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<257> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<256> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<255> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<254> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<253> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<252> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<251> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<250> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<249> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<248> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<247> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<246> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<245> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<244> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<243> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<242> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<241> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<240> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<239> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<238> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<237> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<236> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<235> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<234> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<233> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<232> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<231> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<230> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<229> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<228> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<227> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<226> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<225> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<224> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<223> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<222> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<221> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<220> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<219> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<218> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<217> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<216> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<215> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<214> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<213> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<212> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<211> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<210> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<209> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<208> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<207> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<206> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<205> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<204> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<203> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<202> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<201> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<200> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<199> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<198> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<197> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<196> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<195> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<194> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<193> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<192> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<191> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<190> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<189> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<188> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<187> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<186> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<185> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<184> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<183> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<182> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<181> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<180> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<179> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<178> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<177> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<176> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<175> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<174> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<173> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<172> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<171> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<170> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<169> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<168> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<167> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<166> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<165> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<164> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<163> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<162> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<161> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<160> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<159> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<158> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<157> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<156> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<155> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<154> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<153> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<152> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<151> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<150> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<149> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<148> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<147> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<146> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<145> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<144> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<143> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<142> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<141> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<140> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<139> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<138> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<137> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<136> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<135> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<134> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<133> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<132> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<131> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<130> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<129> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<128> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<127> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<126> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<125> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<124> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<123> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<122> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<121> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<120> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<119> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<118> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<117> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<116> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<115> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<114> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<113> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<112> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<111> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<110> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<109> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<108> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<107> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<106> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<105> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<104> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<103> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<102> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<101> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<100> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<99> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<98> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<97> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<96> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<95> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<94> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<93> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<92> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<91> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<90> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<89> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<88> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<87> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<86> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<85> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<84> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<83> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<82> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<81> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<80> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<79> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<78> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<77> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<76> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<75> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<74> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<73> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<72> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<71> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<70> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<69> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<68> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<67> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<66> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<65> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<64> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<63> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<62> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<61> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<60> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<59> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<58> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<57> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<56> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<55> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<54> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<53> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<52> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<51> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<50> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<49> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<48> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<47> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<46> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<45> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<44> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<43> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<42> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<41> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<40> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<39> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<38> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<37> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<36> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<35> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<34> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<33> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<32> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<31> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<30> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<29> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<28> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<27> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<26> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<25> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<24> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<23> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<22> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<21> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<20> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<19> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<18> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<17> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<16> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<15> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<14> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<13> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<12> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<11> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<10> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<9> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<8> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<7> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<6> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<5> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<4> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<3> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<2> VDD VSS inh_bulk_p phy_supplybl_m2
  XI14<1> VDD VSS inh_bulk_p phy_supplybl_m2
  Xdeser VDD VSS clk_n_i clk_p_i dft_hstx_data_loopback_o<15> dft_hstx_data_loopback_o<14> dft_hstx_data_loopback_o<13> dft_hstx_data_loopback_o<12> dft_hstx_data_loopback_o<11> dft_hstx_data_loopback_o<10> dft_hstx_data_loopback_o<9> dft_hstx_data_loopback_o<8>
+ dft_hstx_data_loopback_o<7> dft_hstx_data_loopback_o<6> dft_hstx_data_loopback_o<5> dft_hstx_data_loopback_o<4> dft_hstx_data_loopback_o<3> dft_hstx_data_loopback_o<2> dft_hstx_data_loopback_o<1> dft_hstx_data_loopback_o<0> ser_pn_s en_deserializer_i
+ dphy_reset_n_i inh_bulk_n inh_bulk_p phy_hr_deser
  Xhstx_data VDD VSS dft_ser_test_in_en dft_ser_test_n_i dft_ser_test_p_i dis_res_i hstx_en_fast_trf_i hstx_calib_lower_impedance<2> hstx_calib_lower_impedance<1> hstx_calib_lower_impedance<0> hstx_calib_upper_impedance<2> hstx_calib_upper_impedance<1>
+ hstx_calib_upper_impedance<0> hstx_en_lptx_dis dft_hstx_ldo_monitor_en_i dft_hstx_ldo_monitor_vout_o hstx_ldo_vref dft_hstx_lower_path_en data_dl_n_s hstx_pwrdn_s ibias5_10u_s ibias3_10u_s pad_n_s pad_p_s inh_bulk_n inh_bulk_p phy_hstx
  V1 ibias1_25u_s net081 DC='0'
  V0 ibias2_25u_s net082 DC='0'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: CLK6
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT CLK6 A Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mptrans15 net24 A inh_hSup inh_bulk_p PREG W='2.44u' L='120.0n' M='1'
  Mptrans14 Z net24 inh_hSup inh_bulk_p PREG W='4.86u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='7.2e-12'
  Mntrans13 net24 A inh_lSup inh_bulk_n NREG W='1.06u' L='120.0n' M='1'
  Mntrans12 Z net24 inh_lSup inh_bulk_n NREG W='2.1u' L='120.0n' M='1'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_ana_core
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_ana_core VDDD1V5 GNDD VDDPHY1V5 GNDPHY hstx_en_fast_trf_i ck50m4iq_p_i div_clk_dphy_i sel_dr_i clk_dphy_270_i dl1_dft_hstx_lower_path_en_i en_clk_dphy_i dl2_dft_hstx_lower_path_en_i hstx_ldo_vref_ai clk_dphy_0_i ck50m4iq_n_i n_mux_iq_sel_i
+ lptx_ldo_vref_ai dl0_dft_hstx_lower_path_en_i clk_dphy_90_i cl_dft_hstx_lower_path_en_i ref_clk_dphy_i dl3_dft_hstx_lower_path_en_i ibias_40u_ai clk_dphy_180_i dl3_dft_hstx_data_lpbk_o<15> dl3_dft_hstx_data_lpbk_o<14> dl3_dft_hstx_data_lpbk_o<13>
+ dl3_dft_hstx_data_lpbk_o<12> dl3_dft_hstx_data_lpbk_o<11> dl3_dft_hstx_data_lpbk_o<10> dl3_dft_hstx_data_lpbk_o<9> dl3_dft_hstx_data_lpbk_o<8> dl3_dft_hstx_data_lpbk_o<7> dl3_dft_hstx_data_lpbk_o<6> dl3_dft_hstx_data_lpbk_o<5> dl3_dft_hstx_data_lpbk_o<4>
+ dl3_dft_hstx_data_lpbk_o<3> dl3_dft_hstx_data_lpbk_o<2> dl3_dft_hstx_data_lpbk_o<1> dl3_dft_hstx_data_lpbk_o<0> dl1_dft_hstx_data_lpbk_o<15> dl1_dft_hstx_data_lpbk_o<14> dl1_dft_hstx_data_lpbk_o<13> dl1_dft_hstx_data_lpbk_o<12> dl1_dft_hstx_data_lpbk_o<11>
+ dl1_dft_hstx_data_lpbk_o<10> dl1_dft_hstx_data_lpbk_o<9> dl1_dft_hstx_data_lpbk_o<8> dl1_dft_hstx_data_lpbk_o<7> dl1_dft_hstx_data_lpbk_o<6> dl1_dft_hstx_data_lpbk_o<5> dl1_dft_hstx_data_lpbk_o<4> dl1_dft_hstx_data_lpbk_o<3> dl1_dft_hstx_data_lpbk_o<2>
+ dl1_dft_hstx_data_lpbk_o<1> dl1_dft_hstx_data_lpbk_o<0> tx_data_3_n_o tx_data_1_p_o tx_data_1_n_o dl1_tx_byte_clk_o tx_data_0_p_o tx_data_0_n_o tx_clk_p_o dl2_dft_hstx_data_lpbk_o<15> dl2_dft_hstx_data_lpbk_o<14> dl2_dft_hstx_data_lpbk_o<13>
+ dl2_dft_hstx_data_lpbk_o<12> dl2_dft_hstx_data_lpbk_o<11> dl2_dft_hstx_data_lpbk_o<10> dl2_dft_hstx_data_lpbk_o<9> dl2_dft_hstx_data_lpbk_o<8> dl2_dft_hstx_data_lpbk_o<7> dl2_dft_hstx_data_lpbk_o<6> dl2_dft_hstx_data_lpbk_o<5> dl2_dft_hstx_data_lpbk_o<4>
+ dl2_dft_hstx_data_lpbk_o<3> dl2_dft_hstx_data_lpbk_o<2> dl2_dft_hstx_data_lpbk_o<1> dl2_dft_hstx_data_lpbk_o<0> cl_dft_hstx_data_lpbk_o<15> cl_dft_hstx_data_lpbk_o<14> cl_dft_hstx_data_lpbk_o<13> cl_dft_hstx_data_lpbk_o<12> cl_dft_hstx_data_lpbk_o<11>
+ cl_dft_hstx_data_lpbk_o<10> cl_dft_hstx_data_lpbk_o<9> cl_dft_hstx_data_lpbk_o<8> cl_dft_hstx_data_lpbk_o<7> cl_dft_hstx_data_lpbk_o<6> cl_dft_hstx_data_lpbk_o<5> cl_dft_hstx_data_lpbk_o<4> cl_dft_hstx_data_lpbk_o<3> cl_dft_hstx_data_lpbk_o<2>
+ cl_dft_hstx_data_lpbk_o<1> cl_dft_hstx_data_lpbk_o<0> dl0_dft_hstx_data_lpbk_o<15> dl0_dft_hstx_data_lpbk_o<14> dl0_dft_hstx_data_lpbk_o<13> dl0_dft_hstx_data_lpbk_o<12> dl0_dft_hstx_data_lpbk_o<11> dl0_dft_hstx_data_lpbk_o<10> dl0_dft_hstx_data_lpbk_o<9>
+ dl0_dft_hstx_data_lpbk_o<8> dl0_dft_hstx_data_lpbk_o<7> dl0_dft_hstx_data_lpbk_o<6> dl0_dft_hstx_data_lpbk_o<5> dl0_dft_hstx_data_lpbk_o<4> dl0_dft_hstx_data_lpbk_o<3> dl0_dft_hstx_data_lpbk_o<2> dl0_dft_hstx_data_lpbk_o<1> dl0_dft_hstx_data_lpbk_o<0>
+ tx_data_2_p_o tx_clk_n_o tx_data_2_n_o dft_ana_test_ao tx_data_3_p_o dl3_hstx_data_i<15> dl3_hstx_data_i<14> dl3_hstx_data_i<13> dl3_hstx_data_i<12> dl3_hstx_data_i<11> dl3_hstx_data_i<10> dl3_hstx_data_i<9> dl3_hstx_data_i<8> dl3_hstx_data_i<7>
+ dl3_hstx_data_i<6> dl3_hstx_data_i<5> dl3_hstx_data_i<4> dl3_hstx_data_i<3> dl3_hstx_data_i<2> dl3_hstx_data_i<1> dl3_hstx_data_i<0> dl3_hs_ser_en_i dl3_hstx_pwrdn_i dl3_hstx_en_lptx_dis_i dl3_lptx_en_i dl3_lptx_dp_i dl3_lptx_dn_i dl3_dft_deser_en_i
+ dl3_bypass_delay_line_i dl3_dft_ser_test_in_en_i dl3_dft_ser_test_n_i dl3_dft_ser_test_p_i dl3_delay_prog_i<2> dl3_delay_prog_i<1> dl3_delay_prog_i<0> dl1_hstx_data_i<15> dl1_hstx_data_i<14> dl1_hstx_data_i<13> dl1_hstx_data_i<12> dl1_hstx_data_i<11>
+ dl1_hstx_data_i<10> dl1_hstx_data_i<9> dl1_hstx_data_i<8> dl1_hstx_data_i<7> dl1_hstx_data_i<6> dl1_hstx_data_i<5> dl1_hstx_data_i<4> dl1_hstx_data_i<3> dl1_hstx_data_i<2> dl1_hstx_data_i<1> dl1_hstx_data_i<0> dl1_dft_deser_en_i dl1_hstx_en_lptx_dis_i
+ dl1_hstx_pwrdn_i dl1_lptx_dn_i dl1_dft_ser_test_n_i dl1_delay_prog_i<2> dl1_delay_prog_i<1> dl1_delay_prog_i<0> dl1_bypass_delay_line_i dl0_hstx_data_i<15> dl0_hstx_data_i<14> dl0_hstx_data_i<13> dl0_hstx_data_i<12> dl0_hstx_data_i<11> dl0_hstx_data_i<10>
+ dl0_hstx_data_i<9> dl0_hstx_data_i<8> dl0_hstx_data_i<7> dl0_hstx_data_i<6> dl0_hstx_data_i<5> dl0_hstx_data_i<4> dl0_hstx_data_i<3> dl0_hstx_data_i<2> dl0_hstx_data_i<1> dl0_hstx_data_i<0> dl1_lptx_dp_i dl1_lptx_en_i dl1_hs_ser_en_i lptx_vref_prog_i<4>
+ lptx_vref_prog_i<3> lptx_vref_prog_i<2> lptx_vref_prog_i<1> lptx_vref_prog_i<0> en_ls_vddphy_i dl0_dft_ser_test_p_i cl_dft_ser_test_in_en_i dl2_dft_ser_test_p_i dl2_dft_ser_test_in_en_i dft_ana_test_en_i dl2_dft_ser_test_n_i dl0_dft_ser_test_in_en_i
+ dl2_hstx_en_lptx_dis_i cl_lptx_dp_i dl2_lptx_dn_i hstx_lower_imp_cal_i<2> hstx_lower_imp_cal_i<1> hstx_lower_imp_cal_i<0> dphy_reset_n_i dl0_dft_ser_test_n_i dl0_delay_prog_i<2> dl0_delay_prog_i<1> dl0_delay_prog_i<0> dl0_lptx_dn_i cl_hstx_data_i<15>
+ cl_hstx_data_i<14> cl_hstx_data_i<13> cl_hstx_data_i<12> cl_hstx_data_i<11> cl_hstx_data_i<10> cl_hstx_data_i<9> cl_hstx_data_i<8> cl_hstx_data_i<7> cl_hstx_data_i<6> cl_hstx_data_i<5> cl_hstx_data_i<4> cl_hstx_data_i<3> cl_hstx_data_i<2> cl_hstx_data_i<1>
+ cl_hstx_data_i<0> cl_lptx_dn_i dl2_hstx_data_i<15> dl2_hstx_data_i<14> dl2_hstx_data_i<13> dl2_hstx_data_i<12> dl2_hstx_data_i<11> dl2_hstx_data_i<10> dl2_hstx_data_i<9> dl2_hstx_data_i<8> dl2_hstx_data_i<7> dl2_hstx_data_i<6> dl2_hstx_data_i<5>
+ dl2_hstx_data_i<4> dl2_hstx_data_i<3> dl2_hstx_data_i<2> dl2_hstx_data_i<1> dl2_hstx_data_i<0> dl2_lptx_en_i cl_hs_ser_en_i cl_hstx_en_lptx_dis_i dl2_lptx_dp_i cl_delay_prog_i<2> cl_delay_prog_i<1> cl_delay_prog_i<0> dl2_delay_prog_i<2> dl2_delay_prog_i<1>
+ dl2_delay_prog_i<0> cl_hstx_pwrdn_i cl_dft_ser_test_p_i dl2_hs_ser_en_i cl_lptx_en_i dl2_hstx_pwrdn_i dft_pll_clks_2_cl_en_i cl_dft_deser_en_i cl_bypass_delay_line_i dl0_bypass_delay_line_i dl0_dft_deser_en_i dl2_dft_deser_en_i dl2_bypass_delay_line_i
+ dphy_pwrdn_i cl_dft_ser_test_n_i dl1_dft_ser_test_p_i dl1_dft_ser_test_in_en_i dl0_hstx_pwrdn_i dl0_hs_ser_en_i hstx_upper_imp_cal_i<2> hstx_upper_imp_cal_i<1> hstx_upper_imp_cal_i<0> dft_dphy_ocdldo_res_dis_i dl0_lptx_dp_i dl0_lptx_en_i dl0_hstx_en_lptx_dis_i
+ hs_ser_msb_first_en_i dft_ana_test_out_dphy_sel_i<3> dft_ana_test_out_dphy_sel_i<2> dft_ana_test_out_dphy_sel_i<1> dft_ana_test_out_dphy_sel_i<0> en_iso_vddphy_i inh_bulk_n inh_bulk_p
  R0<18> GNDPHY GNDPHY R='9.969K'
  R0<17> GNDPHY GNDPHY R='9.969K'
  R0<16> GNDPHY GNDPHY R='9.969K'
  R0<15> GNDPHY GNDPHY R='9.969K'
  R0<14> GNDPHY GNDPHY R='9.969K'
  R0<13> GNDPHY GNDPHY R='9.969K'
  R0<12> GNDPHY GNDPHY R='9.969K'
  R0<11> GNDPHY GNDPHY R='9.969K'
  R0<10> GNDPHY GNDPHY R='9.969K'
  R0<9> GNDPHY GNDPHY R='9.969K'
  R0<8> GNDPHY GNDPHY R='9.969K'
  R0<7> GNDPHY GNDPHY R='9.969K'
  R0<6> GNDPHY GNDPHY R='9.969K'
  R0<5> GNDPHY GNDPHY R='9.969K'
  R0<4> GNDPHY GNDPHY R='9.969K'
  R0<3> GNDPHY GNDPHY R='9.969K'
  R0<2> GNDPHY GNDPHY R='9.969K'
  R0<1> GNDPHY GNDPHY R='9.969K'
  XI413 VDDPHY1V5 GNDPHY clk_tx23_p_s clk_tx23_n_s clk_tx2_p_s clk_tx2_n_s inh_bulk_n inh_bulk_p phy_diff_buf2x0
  XI412 VDDPHY1V5 GNDPHY clk_tx01_p_s clk_tx01_n_s clk_tx0_p_s clk_tx0_n_s inh_bulk_n inh_bulk_p phy_diff_buf2x0
  XI423 VDDPHY1V5 GNDPHY clk_clk_p_ss clk_clk_n_ss net0252 net0253 inh_bulk_n inh_bulk_p phy_diff_buf2x0
  XI273 VDDPHY1V5 GNDPHY clk_tx23_p_s clk_tx23_n_s clk_tx3_p_s clk_tx3_n_s inh_bulk_n inh_bulk_p phy_diff_buf2x0
  XI420 VDDPHY1V5 GNDPHY clk_180_s clk_0_s clk_clk_p_ss clk_clk_n_ss inh_bulk_n inh_bulk_p phy_diff_buf2x0
  XI274 VDDPHY1V5 GNDPHY clk_clk_p_ss clk_clk_n_ss clk_clk_p_s clk_clk_n_s inh_bulk_n inh_bulk_p phy_diff_buf2x0
  XI422 VDDPHY1V5 GNDPHY clk_180_s clk_0_s net0250 net0251 inh_bulk_n inh_bulk_p phy_diff_buf2x0
  XI264 VDDPHY1V5 GNDPHY clk_tx01_p_s clk_tx01_n_s clk_tx1_p_s clk_tx1_n_s inh_bulk_n inh_bulk_p phy_diff_buf2x0
  XI421 VDDPHY1V5 GNDPHY clk_270_s clk_90_s clk_tx01_p_s clk_tx01_n_s inh_bulk_n inh_bulk_p phy_diff_buf2x0
  XI417 VDDPHY1V5 GNDPHY clk_270_s clk_90_s clk_tx23_p_s clk_tx23_n_s inh_bulk_n inh_bulk_p phy_diff_buf2x0
  XI364<2> VDDPHY1V5 GNDPHY net0331 net0331 net0336<1> inh_bulk_n inh_bulk_p phy_spare_nand2xp
  XI364<1> VDDPHY1V5 GNDPHY net0331 net0331 net0336<0> inh_bulk_n inh_bulk_p phy_spare_nand2xp
  XI363<2> VDDPHY1V5 GNDPHY net0105 net0105 net0330<1> inh_bulk_n inh_bulk_p phy_spare_nand2xp
  XI363<1> VDDPHY1V5 GNDPHY net0105 net0105 net0330<0> inh_bulk_n inh_bulk_p phy_spare_nand2xp
  XI357<2> VDDPHY1V5 GNDPHY net0337 net0337 net0322<1> inh_bulk_n inh_bulk_p phy_spare_nand2xp
  XI357<1> VDDPHY1V5 GNDPHY net0337 net0337 net0322<0> inh_bulk_n inh_bulk_p phy_spare_nand2xp
  XI349<2> VDDPHY1V5 GNDPHY net099 net099 net0303<1> inh_bulk_n inh_bulk_p phy_spare_nand2xp
  XI349<1> VDDPHY1V5 GNDPHY net099 net099 net0303<0> inh_bulk_n inh_bulk_p phy_spare_nand2xp
  XI353<2> VDDPHY1V5 GNDPHY net0101 net0101 net0302<1> inh_bulk_n inh_bulk_p phy_spare_nand2xp
  XI353<1> VDDPHY1V5 GNDPHY net0101 net0101 net0302<0> inh_bulk_n inh_bulk_p phy_spare_nand2xp
  XI379<2> VDDPHY1V5 GNDPHY net098 net098 net0178<1> inh_bulk_n inh_bulk_p phy_spare_nand2xp
  XI379<1> VDDPHY1V5 GNDPHY net098 net098 net0178<0> inh_bulk_n inh_bulk_p phy_spare_nand2xp
  XI366 net0331 inh_bulk_n inh_bulk_p VDDPHY1V5 GNDPHY TIEZERO
  XI365 net0105 inh_bulk_n inh_bulk_p VDDPHY1V5 GNDPHY TIEZERO
  XI371 net0327 inh_bulk_n inh_bulk_p VDDPHY1V5 GNDPHY TIEZERO
  XI370 net0334 inh_bulk_n inh_bulk_p VDDPHY1V5 GNDPHY TIEZERO
  XI382 net0190 inh_bulk_n inh_bulk_p VDDPHY1V5 GNDPHY TIEZERO
  XI352 net0100 inh_bulk_n inh_bulk_p VDDPHY1V5 GNDPHY TIEZERO
  XI350 net099 inh_bulk_n inh_bulk_p VDDPHY1V5 GNDPHY TIEZERO
  XI354 net0101 inh_bulk_n inh_bulk_p VDDPHY1V5 GNDPHY TIEZERO
  XI348 net0323 inh_bulk_n inh_bulk_p VDDPHY1V5 GNDPHY TIEZERO
  XI358 net0337 inh_bulk_n inh_bulk_p VDDPHY1V5 GNDPHY TIEZERO
  XI380 net098 inh_bulk_n inh_bulk_p VDDPHY1V5 GNDPHY TIEZERO
  XI362 net0104 inh_bulk_n inh_bulk_p VDDPHY1V5 GNDPHY TIEZERO
  Xamux VDDPHY1V5 GNDPHY dft_ana_test_ao dft_dec_s<10> dft_dec_s<9> dft_dec_s<8> dft_dec_s<7> dft_dec_s<6> dft_dec_s<5> dft_dec_s<4> dft_dec_s<3> dft_dec_s<2> dft_dec_s<1> dft_dec_s<0> dft_ana_test_en_s dft_tx0_hstx_ldo_monitor_vout_s
+ dft_tx1_hstx_ldo_monitor_vout_s dft_clk_hstx_ldo_monitor_vout_s dft_tx2_hstx_ldo_monitor_vout_s dft_tx3_hstx_ldo_monitor_vout_s dft_tx0_lptx_ldo_monitor_vout_s dft_tx1_lptx_ldo_monitor_vout_s dft_clk_lptx_ldo_monitor_vout_s dft_tx2_lptx_ldo_monitor_vout_s
+ dft_tx3_lptx_ldo_monitor_vout_s dft_ibias_25u_s dft_ana_test_out_dphy_sel_s<3> dft_ana_test_out_dphy_sel_s<2> dft_ana_test_out_dphy_sel_s<1> dft_ana_test_out_dphy_sel_s<0> inh_bulk_n inh_bulk_p phy_dc_testout
  XI369<2> VDDPHY1V5 GNDPHY net0327 net0327 net0309<1> inh_bulk_n inh_bulk_p phy_spare_nand2
  XI369<1> VDDPHY1V5 GNDPHY net0327 net0327 net0309<0> inh_bulk_n inh_bulk_p phy_spare_nand2
  XI368<2> VDDPHY1V5 GNDPHY net0334 net0334 net0310<1> inh_bulk_n inh_bulk_p phy_spare_nand2
  XI368<1> VDDPHY1V5 GNDPHY net0334 net0334 net0310<0> inh_bulk_n inh_bulk_p phy_spare_nand2
  XI381<2> VDDPHY1V5 GNDPHY net0190 net0190 net0184<1> inh_bulk_n inh_bulk_p phy_spare_nand2
  XI381<1> VDDPHY1V5 GNDPHY net0190 net0190 net0184<0> inh_bulk_n inh_bulk_p phy_spare_nand2
  XI361<2> VDDPHY1V5 GNDPHY net0104 net0104 net0326<1> inh_bulk_n inh_bulk_p phy_spare_nand2
  XI361<1> VDDPHY1V5 GNDPHY net0104 net0104 net0326<0> inh_bulk_n inh_bulk_p phy_spare_nand2
  XI351<2> VDDPHY1V5 GNDPHY net0100 net0100 net0335<1> inh_bulk_n inh_bulk_p phy_spare_nand2
  XI351<1> VDDPHY1V5 GNDPHY net0100 net0100 net0335<0> inh_bulk_n inh_bulk_p phy_spare_nand2
  XI355<2> VDDPHY1V5 GNDPHY net0323 net0323 net0333<1> inh_bulk_n inh_bulk_p phy_spare_nand2
  XI355<1> VDDPHY1V5 GNDPHY net0323 net0323 net0333<0> inh_bulk_n inh_bulk_p phy_spare_nand2
  Xclkmux VDDPHY1V5 GNDPHY ck50m4iq_n_i ck50m4iq_p_i clk_0_s clk_90_s clk_180_s clk_270_s clk_dphy_0_i clk_dphy_90_i clk_dphy_180_i clk_dphy_270_i en_clk_dphy_s n_mux_iq_sel_s dphy_reset_n_s sel_dr_s inh_bulk_n inh_bulk_p phy_clk
  Xfilter GNDPHY lptx_ldo_vref_ai lptx_ldo_vref_as hstx_ldo_vref_ai hstx_ldo_vref_as phy_vref_filter
  Xpgins GNDD GNDPHY VDDD1V5 VDDPHY1V5 cl_bypass_delay_line_i cl_bypass_delay_line_s cl_delay_prog_i<2> cl_delay_prog_i<1> cl_delay_prog_i<0> cl_delay_prog_s<2> cl_delay_prog_s<1> cl_delay_prog_s<0> cl_dft_deser_en_i cl_dft_deser_en_s cl_dft_hstx_data_lpbk_s<15>
+ cl_dft_hstx_data_lpbk_s<14> cl_dft_hstx_data_lpbk_s<13> cl_dft_hstx_data_lpbk_s<12> cl_dft_hstx_data_lpbk_s<11> cl_dft_hstx_data_lpbk_s<10> cl_dft_hstx_data_lpbk_s<9> cl_dft_hstx_data_lpbk_s<8> cl_dft_hstx_data_lpbk_s<7> cl_dft_hstx_data_lpbk_s<6>
+ cl_dft_hstx_data_lpbk_s<5> cl_dft_hstx_data_lpbk_s<4> cl_dft_hstx_data_lpbk_s<3> cl_dft_hstx_data_lpbk_s<2> cl_dft_hstx_data_lpbk_s<1> cl_dft_hstx_data_lpbk_s<0> cl_dft_hstx_data_lpbk_o<15> cl_dft_hstx_data_lpbk_o<14> cl_dft_hstx_data_lpbk_o<13>
+ cl_dft_hstx_data_lpbk_o<12> cl_dft_hstx_data_lpbk_o<11> cl_dft_hstx_data_lpbk_o<10> cl_dft_hstx_data_lpbk_o<9> cl_dft_hstx_data_lpbk_o<8> cl_dft_hstx_data_lpbk_o<7> cl_dft_hstx_data_lpbk_o<6> cl_dft_hstx_data_lpbk_o<5> cl_dft_hstx_data_lpbk_o<4>
+ cl_dft_hstx_data_lpbk_o<3> cl_dft_hstx_data_lpbk_o<2> cl_dft_hstx_data_lpbk_o<1> cl_dft_hstx_data_lpbk_o<0> cl_dft_hstx_lower_path_en_i cl_dft_hstx_lower_path_en_s cl_dft_ser_test_in_en_i cl_dft_ser_test_in_en_s cl_dft_ser_test_n_i cl_dft_ser_test_n_s
+ cl_dft_ser_test_p_i cl_dft_ser_test_p_s cl_hs_ser_en_i cl_hs_ser_en_s cl_hstx_data_i<15> cl_hstx_data_i<14> cl_hstx_data_i<13> cl_hstx_data_i<12> cl_hstx_data_i<11> cl_hstx_data_i<10> cl_hstx_data_i<9> cl_hstx_data_i<8> cl_hstx_data_i<7> cl_hstx_data_i<6>
+ cl_hstx_data_i<5> cl_hstx_data_i<4> cl_hstx_data_i<3> cl_hstx_data_i<2> cl_hstx_data_i<1> cl_hstx_data_i<0> cl_hstx_data_s<15> cl_hstx_data_s<14> cl_hstx_data_s<13> cl_hstx_data_s<12> cl_hstx_data_s<11> cl_hstx_data_s<10> cl_hstx_data_s<9> cl_hstx_data_s<8>
+ cl_hstx_data_s<7> cl_hstx_data_s<6> cl_hstx_data_s<5> cl_hstx_data_s<4> cl_hstx_data_s<3> cl_hstx_data_s<2> cl_hstx_data_s<1> cl_hstx_data_s<0> cl_hstx_en_lptx_dis_i cl_hstx_en_lptx_dis_s cl_hstx_pwrdn_i cl_hstx_pwrdn_s cl_lptx_dn_i cl_lptx_dn_s cl_lptx_dp_i
+ cl_lptx_dp_s cl_lptx_en_i cl_lptx_en_s dft_ana_test_en_i dft_ana_test_en_s dft_ana_test_out_dphy_sel_i<3> dft_ana_test_out_dphy_sel_i<2> dft_ana_test_out_dphy_sel_i<1> dft_ana_test_out_dphy_sel_i<0> dft_ana_test_out_dphy_sel_s<3> dft_ana_test_out_dphy_sel_s<2>
+ dft_ana_test_out_dphy_sel_s<1> dft_ana_test_out_dphy_sel_s<0> dft_dphy_ocdldo_res_dis_i dft_dphy_ocdldo_res_dis_s dft_pll_clks_2_cl_en_i dft_pll_clks_2_cl_en_s dl0_bypass_delay_line_i dl0_bypass_delay_line_s dl0_delay_prog_i<2> dl0_delay_prog_i<1>
+ dl0_delay_prog_i<0> dl0_delay_prog_s<2> dl0_delay_prog_s<1> dl0_delay_prog_s<0> dl0_dft_deser_en_i dl0_dft_deser_en_s dl0_dft_hstx_data_lpbk_s<15> dl0_dft_hstx_data_lpbk_s<14> dl0_dft_hstx_data_lpbk_s<13> dl0_dft_hstx_data_lpbk_s<12>
+ dl0_dft_hstx_data_lpbk_s<11> dl0_dft_hstx_data_lpbk_s<10> dl0_dft_hstx_data_lpbk_s<9> dl0_dft_hstx_data_lpbk_s<8> dl0_dft_hstx_data_lpbk_s<7> dl0_dft_hstx_data_lpbk_s<6> dl0_dft_hstx_data_lpbk_s<5> dl0_dft_hstx_data_lpbk_s<4> dl0_dft_hstx_data_lpbk_s<3>
+ dl0_dft_hstx_data_lpbk_s<2> dl0_dft_hstx_data_lpbk_s<1> dl0_dft_hstx_data_lpbk_s<0> dl0_dft_hstx_data_lpbk_o<15> dl0_dft_hstx_data_lpbk_o<14> dl0_dft_hstx_data_lpbk_o<13> dl0_dft_hstx_data_lpbk_o<12> dl0_dft_hstx_data_lpbk_o<11> dl0_dft_hstx_data_lpbk_o<10>
+ dl0_dft_hstx_data_lpbk_o<9> dl0_dft_hstx_data_lpbk_o<8> dl0_dft_hstx_data_lpbk_o<7> dl0_dft_hstx_data_lpbk_o<6> dl0_dft_hstx_data_lpbk_o<5> dl0_dft_hstx_data_lpbk_o<4> dl0_dft_hstx_data_lpbk_o<3> dl0_dft_hstx_data_lpbk_o<2> dl0_dft_hstx_data_lpbk_o<1>
+ dl0_dft_hstx_data_lpbk_o<0> dl0_dft_hstx_lower_path_en_i dl0_dft_hstx_lower_path_en_s dl0_dft_ser_test_in_en_i dl0_dft_ser_test_in_en_s dl0_dft_ser_test_n_i dl0_dft_ser_test_n_s dl0_dft_ser_test_p_i dl0_dft_ser_test_p_s dl0_hs_ser_en_i dl0_hs_ser_en_s
+ dl0_hstx_data_i<15> dl0_hstx_data_i<14> dl0_hstx_data_i<13> dl0_hstx_data_i<12> dl0_hstx_data_i<11> dl0_hstx_data_i<10> dl0_hstx_data_i<9> dl0_hstx_data_i<8> dl0_hstx_data_i<7> dl0_hstx_data_i<6> dl0_hstx_data_i<5> dl0_hstx_data_i<4> dl0_hstx_data_i<3>
+ dl0_hstx_data_i<2> dl0_hstx_data_i<1> dl0_hstx_data_i<0> dl0_hstx_data_s<15> dl0_hstx_data_s<14> dl0_hstx_data_s<13> dl0_hstx_data_s<12> dl0_hstx_data_s<11> dl0_hstx_data_s<10> dl0_hstx_data_s<9> dl0_hstx_data_s<8> dl0_hstx_data_s<7> dl0_hstx_data_s<6>
+ dl0_hstx_data_s<5> dl0_hstx_data_s<4> dl0_hstx_data_s<3> dl0_hstx_data_s<2> dl0_hstx_data_s<1> dl0_hstx_data_s<0> dl0_hstx_en_lptx_dis_i dl0_hstx_en_lptx_dis_s dl0_hstx_pwrdn_i dl0_hstx_pwrdn_s dl0_lptx_dn_i dl0_lptx_dn_s dl0_lptx_dp_i dl0_lptx_dp_s
+ dl0_lptx_en_i dl0_lptx_en_s dl1_bypass_delay_line_i dl1_bypass_delay_line_s dl1_delay_prog_i<2> dl1_delay_prog_i<1> dl1_delay_prog_i<0> dl1_delay_prog_s<2> dl1_delay_prog_s<1> dl1_delay_prog_s<0> dl1_dft_deser_en_i dl1_dft_deser_en_s
+ dl1_dft_hstx_data_lpbk_s<15> dl1_dft_hstx_data_lpbk_s<14> dl1_dft_hstx_data_lpbk_s<13> dl1_dft_hstx_data_lpbk_s<12> dl1_dft_hstx_data_lpbk_s<11> dl1_dft_hstx_data_lpbk_s<10> dl1_dft_hstx_data_lpbk_s<9> dl1_dft_hstx_data_lpbk_s<8> dl1_dft_hstx_data_lpbk_s<7>
+ dl1_dft_hstx_data_lpbk_s<6> dl1_dft_hstx_data_lpbk_s<5> dl1_dft_hstx_data_lpbk_s<4> dl1_dft_hstx_data_lpbk_s<3> dl1_dft_hstx_data_lpbk_s<2> dl1_dft_hstx_data_lpbk_s<1> dl1_dft_hstx_data_lpbk_s<0> dl1_dft_hstx_data_lpbk_o<15> dl1_dft_hstx_data_lpbk_o<14>
+ dl1_dft_hstx_data_lpbk_o<13> dl1_dft_hstx_data_lpbk_o<12> dl1_dft_hstx_data_lpbk_o<11> dl1_dft_hstx_data_lpbk_o<10> dl1_dft_hstx_data_lpbk_o<9> dl1_dft_hstx_data_lpbk_o<8> dl1_dft_hstx_data_lpbk_o<7> dl1_dft_hstx_data_lpbk_o<6> dl1_dft_hstx_data_lpbk_o<5>
+ dl1_dft_hstx_data_lpbk_o<4> dl1_dft_hstx_data_lpbk_o<3> dl1_dft_hstx_data_lpbk_o<2> dl1_dft_hstx_data_lpbk_o<1> dl1_dft_hstx_data_lpbk_o<0> dl1_dft_hstx_lower_path_en_i dl1_dft_hstx_lower_path_en_s dl1_dft_ser_test_in_en_i dl1_dft_ser_test_in_en_s
+ dl1_dft_ser_test_n_i dl1_dft_ser_test_n_s dl1_dft_ser_test_p_i dl1_dft_ser_test_p_s dl1_hs_ser_en_i dl1_hs_ser_en_s dl1_hstx_data_i<15> dl1_hstx_data_i<14> dl1_hstx_data_i<13> dl1_hstx_data_i<12> dl1_hstx_data_i<11> dl1_hstx_data_i<10> dl1_hstx_data_i<9>
+ dl1_hstx_data_i<8> dl1_hstx_data_i<7> dl1_hstx_data_i<6> dl1_hstx_data_i<5> dl1_hstx_data_i<4> dl1_hstx_data_i<3> dl1_hstx_data_i<2> dl1_hstx_data_i<1> dl1_hstx_data_i<0> dl1_hstx_data_s<15> dl1_hstx_data_s<14> dl1_hstx_data_s<13> dl1_hstx_data_s<12>
+ dl1_hstx_data_s<11> dl1_hstx_data_s<10> dl1_hstx_data_s<9> dl1_hstx_data_s<8> dl1_hstx_data_s<7> dl1_hstx_data_s<6> dl1_hstx_data_s<5> dl1_hstx_data_s<4> dl1_hstx_data_s<3> dl1_hstx_data_s<2> dl1_hstx_data_s<1> dl1_hstx_data_s<0> dl1_hstx_en_lptx_dis_i
+ dl1_hstx_en_lptx_dis_s dl1_hstx_pwrdn_i dl1_hstx_pwrdn_s dl1_lptx_dn_i dl1_lptx_dn_s dl1_lptx_dp_i dl1_lptx_dp_s dl1_lptx_en_i dl1_lptx_en_s clk_byte_s dl1_tx_byte_clk_o dl2_bypass_delay_line_i dl2_bypass_delay_line_s dl2_delay_prog_i<2> dl2_delay_prog_i<1>
+ dl2_delay_prog_i<0> dl2_delay_prog_s<2> dl2_delay_prog_s<1> dl2_delay_prog_s<0> dl2_dft_deser_en_i dl2_dft_deser_en_s dl2_dft_hstx_data_lpbk_s<15> dl2_dft_hstx_data_lpbk_s<14> dl2_dft_hstx_data_lpbk_s<13> dl2_dft_hstx_data_lpbk_s<12>
+ dl2_dft_hstx_data_lpbk_s<11> dl2_dft_hstx_data_lpbk_s<10> dl2_dft_hstx_data_lpbk_s<9> dl2_dft_hstx_data_lpbk_s<8> dl2_dft_hstx_data_lpbk_s<7> dl2_dft_hstx_data_lpbk_s<6> dl2_dft_hstx_data_lpbk_s<5> dl2_dft_hstx_data_lpbk_s<4> dl2_dft_hstx_data_lpbk_s<3>
+ dl2_dft_hstx_data_lpbk_s<2> dl2_dft_hstx_data_lpbk_s<1> dl2_dft_hstx_data_lpbk_s<0> dl2_dft_hstx_data_lpbk_o<15> dl2_dft_hstx_data_lpbk_o<14> dl2_dft_hstx_data_lpbk_o<13> dl2_dft_hstx_data_lpbk_o<12> dl2_dft_hstx_data_lpbk_o<11> dl2_dft_hstx_data_lpbk_o<10>
+ dl2_dft_hstx_data_lpbk_o<9> dl2_dft_hstx_data_lpbk_o<8> dl2_dft_hstx_data_lpbk_o<7> dl2_dft_hstx_data_lpbk_o<6> dl2_dft_hstx_data_lpbk_o<5> dl2_dft_hstx_data_lpbk_o<4> dl2_dft_hstx_data_lpbk_o<3> dl2_dft_hstx_data_lpbk_o<2> dl2_dft_hstx_data_lpbk_o<1>
+ dl2_dft_hstx_data_lpbk_o<0> dl2_dft_hstx_lower_path_en_i dl2_dft_hstx_lower_path_en_s dl2_dft_ser_test_in_en_i dl2_dft_ser_test_in_en_s dl2_dft_ser_test_n_i dl2_dft_ser_test_n_s dl2_dft_ser_test_p_i dl2_dft_ser_test_p_s dl2_hs_ser_en_i dl2_hs_ser_en_s
+ dl2_hstx_data_i<15> dl2_hstx_data_i<14> dl2_hstx_data_i<13> dl2_hstx_data_i<12> dl2_hstx_data_i<11> dl2_hstx_data_i<10> dl2_hstx_data_i<9> dl2_hstx_data_i<8> dl2_hstx_data_i<7> dl2_hstx_data_i<6> dl2_hstx_data_i<5> dl2_hstx_data_i<4> dl2_hstx_data_i<3>
+ dl2_hstx_data_i<2> dl2_hstx_data_i<1> dl2_hstx_data_i<0> dl2_hstx_data_s<15> dl2_hstx_data_s<14> dl2_hstx_data_s<13> dl2_hstx_data_s<12> dl2_hstx_data_s<11> dl2_hstx_data_s<10> dl2_hstx_data_s<9> dl2_hstx_data_s<8> dl2_hstx_data_s<7> dl2_hstx_data_s<6>
+ dl2_hstx_data_s<5> dl2_hstx_data_s<4> dl2_hstx_data_s<3> dl2_hstx_data_s<2> dl2_hstx_data_s<1> dl2_hstx_data_s<0> dl2_hstx_en_lptx_dis_i dl2_hstx_en_lptx_dis_s dl2_hstx_pwrdn_i dl2_hstx_pwrdn_s dl2_lptx_dn_i dl2_lptx_dn_s dl2_lptx_dp_i dl2_lptx_dp_s
+ dl2_lptx_en_i dl2_lptx_en_s dl3_bypass_delay_line_i dl3_bypass_delay_line_s dl3_delay_prog_i<2> dl3_delay_prog_i<1> dl3_delay_prog_i<0> dl3_delay_prog_s<2> dl3_delay_prog_s<1> dl3_delay_prog_s<0> dl3_dft_deser_en_i dl3_dft_deser_en_s
+ dl3_dft_hstx_data_lpbk_s<15> dl3_dft_hstx_data_lpbk_s<14> dl3_dft_hstx_data_lpbk_s<13> dl3_dft_hstx_data_lpbk_s<12> dl3_dft_hstx_data_lpbk_s<11> dl3_dft_hstx_data_lpbk_s<10> dl3_dft_hstx_data_lpbk_s<9> dl3_dft_hstx_data_lpbk_s<8> dl3_dft_hstx_data_lpbk_s<7>
+ dl3_dft_hstx_data_lpbk_s<6> dl3_dft_hstx_data_lpbk_s<5> dl3_dft_hstx_data_lpbk_s<4> dl3_dft_hstx_data_lpbk_s<3> dl3_dft_hstx_data_lpbk_s<2> dl3_dft_hstx_data_lpbk_s<1> dl3_dft_hstx_data_lpbk_s<0> dl3_dft_hstx_data_lpbk_o<15> dl3_dft_hstx_data_lpbk_o<14>
+ dl3_dft_hstx_data_lpbk_o<13> dl3_dft_hstx_data_lpbk_o<12> dl3_dft_hstx_data_lpbk_o<11> dl3_dft_hstx_data_lpbk_o<10> dl3_dft_hstx_data_lpbk_o<9> dl3_dft_hstx_data_lpbk_o<8> dl3_dft_hstx_data_lpbk_o<7> dl3_dft_hstx_data_lpbk_o<6> dl3_dft_hstx_data_lpbk_o<5>
+ dl3_dft_hstx_data_lpbk_o<4> dl3_dft_hstx_data_lpbk_o<3> dl3_dft_hstx_data_lpbk_o<2> dl3_dft_hstx_data_lpbk_o<1> dl3_dft_hstx_data_lpbk_o<0> dl3_dft_hstx_lower_path_en_i dl3_dft_hstx_lower_path_en_s dl3_dft_ser_test_in_en_i dl3_dft_ser_test_in_en_s
+ dl3_dft_ser_test_n_i dl3_dft_ser_test_n_s dl3_dft_ser_test_p_i dl3_dft_ser_test_p_s dl3_hs_ser_en_i dl3_hs_ser_en_s dl3_hstx_data_i<15> dl3_hstx_data_i<14> dl3_hstx_data_i<13> dl3_hstx_data_i<12> dl3_hstx_data_i<11> dl3_hstx_data_i<10> dl3_hstx_data_i<9>
+ dl3_hstx_data_i<8> dl3_hstx_data_i<7> dl3_hstx_data_i<6> dl3_hstx_data_i<5> dl3_hstx_data_i<4> dl3_hstx_data_i<3> dl3_hstx_data_i<2> dl3_hstx_data_i<1> dl3_hstx_data_i<0> dl3_hstx_data_s<15> dl3_hstx_data_s<14> dl3_hstx_data_s<13> dl3_hstx_data_s<12>
+ dl3_hstx_data_s<11> dl3_hstx_data_s<10> dl3_hstx_data_s<9> dl3_hstx_data_s<8> dl3_hstx_data_s<7> dl3_hstx_data_s<6> dl3_hstx_data_s<5> dl3_hstx_data_s<4> dl3_hstx_data_s<3> dl3_hstx_data_s<2> dl3_hstx_data_s<1> dl3_hstx_data_s<0> dl3_hstx_en_lptx_dis_i
+ dl3_hstx_en_lptx_dis_s dl3_hstx_pwrdn_i dl3_hstx_pwrdn_s dl3_lptx_dn_i dl3_lptx_dn_s dl3_lptx_dp_i dl3_lptx_dp_s dl3_lptx_en_i dl3_lptx_en_s dphy_pwrdn_i dphy_pwrdn_s dphy_reset_n_i dphy_reset_n_s en_clk_dphy_i en_clk_dphy_s en_iso_vddphy_i
+ hs_ser_msb_first_en_i hs_ser_msb_first_en_s hstx_en_fast_trf_i hstx_en_fast_trf_s hstx_lower_imp_cal_i<2> hstx_lower_imp_cal_i<1> hstx_lower_imp_cal_i<0> hstx_lower_imp_cal_s<2> hstx_lower_imp_cal_s<1> hstx_lower_imp_cal_s<0> hstx_upper_imp_cal_i<2>
+ hstx_upper_imp_cal_i<1> hstx_upper_imp_cal_i<0> hstx_upper_imp_cal_s<2> hstx_upper_imp_cal_s<1> hstx_upper_imp_cal_s<0> lptx_vref_prog_i<4> lptx_vref_prog_i<3> lptx_vref_prog_i<2> lptx_vref_prog_i<1> lptx_vref_prog_i<0> lptx_vref_prog_s<4> lptx_vref_prog_s<3>
+ lptx_vref_prog_s<2> lptx_vref_prog_s<1> lptx_vref_prog_s<0> n_mux_iq_sel_i n_mux_iq_sel_s sel_dr_i sel_dr_s inh_bulk_n inh_bulk_p phy_mipi_gpin
  Xdftmux cl_dft_ser_test_p_s net0170 dftmux_a_s dl1_dft_ser_test_p_s net0236 dftmux_b_s dft_pll_clks_2_cl_en_s VDDPHY1V5 GNDPHY inh_bulk_n inh_bulk_p phy_dft_mux
  Xbias VDDPHY1V5 GNDPHY dft_ibias_25u_s net0173 v_ibias_s<9> v_ibias_s<8> v_ibias_s<7> v_ibias_s<6> v_ibias_s<5> v_ibias_s<4> v_ibias_s<3> v_ibias_s<2> v_ibias_s<1> v_ibias_s<0> dphy_pwrdn_s en_ls_vddphy_i ibias_40u_ai inh_bulk_n inh_bulk_p
+ phy_bias_distributor_top
  Xcap<229> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<228> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<227> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<226> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<225> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<224> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<223> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<222> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<221> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<220> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<219> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<218> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<217> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<216> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<215> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<214> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<213> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<212> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<211> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<210> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<209> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<208> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<207> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<206> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<205> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<204> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<203> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<202> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<201> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<200> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<199> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<198> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<197> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<196> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<195> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<194> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<193> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<192> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<191> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<190> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<189> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<188> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<187> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<186> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<185> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<184> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<183> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<182> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<181> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<180> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<179> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<178> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<177> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<176> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<175> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<174> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<173> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<172> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<171> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<170> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<169> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<168> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<167> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<166> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<165> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<164> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<163> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<162> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<161> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<160> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<159> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<158> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<157> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<156> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<155> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<154> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<153> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<152> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<151> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<150> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<149> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<148> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<147> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<146> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<145> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<144> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<143> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<142> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<141> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<140> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<139> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<138> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<137> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<136> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<135> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<134> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<133> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<132> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<131> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<130> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<129> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<128> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<127> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<126> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<125> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<124> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<123> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<122> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<121> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<120> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<119> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<118> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<117> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<116> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<115> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<114> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<113> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<112> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<111> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<110> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<109> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<108> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<107> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<106> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<105> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<104> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<103> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<102> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<101> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<100> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<99> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<98> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<97> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<96> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<95> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<94> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<93> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<92> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<91> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<90> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<89> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<88> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<87> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<86> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<85> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<84> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<83> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<82> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<81> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<80> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<79> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<78> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<77> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<76> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<75> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<74> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<73> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<72> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<71> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<70> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<69> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<68> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<67> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<66> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<65> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<64> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<63> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<62> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<61> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<60> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<59> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<58> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<57> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<56> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<55> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<54> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<53> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<52> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<51> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<50> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<49> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<48> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<47> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<46> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<45> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<44> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<43> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<42> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<41> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<40> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<39> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<38> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<37> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<36> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<35> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<34> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<33> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<32> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<31> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<30> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<29> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<28> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<27> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<26> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<25> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<24> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<23> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<22> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<21> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<20> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<19> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<18> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<17> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<16> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<15> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<14> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<13> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<12> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<11> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<10> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<9> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<8> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<7> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<6> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<5> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<4> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<3> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<2> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  Xcap<1> VDDPHY1V5 GNDPHY inh_bulk_p phy_supplybl_m2
  C31 clk_tx2_n_s GNDPHY C='30f'
  C34 clk_clk_n_s GNDPHY C='32f'
  C28 clk_270_s GNDPHY C='71f'
  C24 clk_tx23_p_s GNDPHY C='44f'
  C25 clk_180_s GNDPHY C='60f'
  C26 clk_0_s GNDPHY C='61f'
  C30 clk_tx3_n_s GNDPHY C='30f'
  C29 clk_tx3_p_s GNDPHY C='39f'
  C22 clk_clk_n_ss GNDPHY C='44f'
  C27 clk_90_s GNDPHY C='72f'
  C32 clk_tx2_p_s GNDPHY C='38f'
  C23 clk_tx23_n_s GNDPHY C='43f'
  C21 clk_clk_p_ss GNDPHY C='39f'
  C9 clk_tx01_n_s GNDPHY C='42f'
  C38 clk_tx0_n_s GNDPHY C='30f'
  C36 clk_tx1_p_s GNDPHY C='39f'
  C37 clk_tx0_p_s GNDPHY C='38f'
  C35 clk_tx1_n_s GNDPHY C='30f'
  C33 clk_clk_p_s GNDPHY C='40f'
  C20 clk_tx01_p_s GNDPHY C='44f'
  Xclk VDDPHY1V5 GNDPHY cl_bypass_delay_line_s net0472 clk_clk_n_s clk_clk_p_s cl_dft_hstx_data_lpbk_s<15> cl_dft_hstx_data_lpbk_s<14> cl_dft_hstx_data_lpbk_s<13> cl_dft_hstx_data_lpbk_s<12> cl_dft_hstx_data_lpbk_s<11> cl_dft_hstx_data_lpbk_s<10>
+ cl_dft_hstx_data_lpbk_s<9> cl_dft_hstx_data_lpbk_s<8> cl_dft_hstx_data_lpbk_s<7> cl_dft_hstx_data_lpbk_s<6> cl_dft_hstx_data_lpbk_s<5> cl_dft_hstx_data_lpbk_s<4> cl_dft_hstx_data_lpbk_s<3> cl_dft_hstx_data_lpbk_s<2> cl_dft_hstx_data_lpbk_s<1>
+ cl_dft_hstx_data_lpbk_s<0> dft_dec_s<2> dft_clk_hstx_ldo_monitor_vout_s cl_dft_hstx_lower_path_en_s dft_dec_s<7> dft_clk_lptx_ldo_monitor_vout_s cl_dft_ser_test_in_en_s cl_dft_ser_test_n_s dftmux_a_s dft_dphy_ocdldo_res_dis_s dphy_pwrdn_s dphy_reset_n_s
+ cl_dft_deser_en_s cl_hs_ser_en_s hs_ser_msb_first_en_s hstx_lower_imp_cal_s<2> hstx_lower_imp_cal_s<1> hstx_lower_imp_cal_s<0> hstx_upper_imp_cal_s<2> hstx_upper_imp_cal_s<1> hstx_upper_imp_cal_s<0> cl_hstx_data_s<15> cl_hstx_data_s<14> cl_hstx_data_s<13>
+ cl_hstx_data_s<12> cl_hstx_data_s<11> cl_hstx_data_s<10> cl_hstx_data_s<9> cl_hstx_data_s<8> cl_hstx_data_s<7> cl_hstx_data_s<6> cl_hstx_data_s<5> cl_hstx_data_s<4> cl_hstx_data_s<3> cl_hstx_data_s<2> cl_hstx_data_s<1> cl_hstx_data_s<0> hstx_en_fast_trf_s
+ cl_hstx_en_lptx_dis_s hstx_ldo_vref_as cl_hstx_pwrdn_s v_ibias_s<4> v_ibias_s<5> cl_lptx_dn_s cl_lptx_dp_s cl_lptx_en_s lptx_ldo_vref_as lptx_vref_prog_s<4> lptx_vref_prog_s<3> lptx_vref_prog_s<2> lptx_vref_prog_s<1> lptx_vref_prog_s<0> tx_clk_n_o tx_clk_p_o
+ cl_delay_prog_s<2> cl_delay_prog_s<1> cl_delay_prog_s<0> inh_bulk_n inh_bulk_p phy_lane
  Xtx0 VDDPHY1V5 GNDPHY dl0_bypass_delay_line_s net0470 clk_tx0_n_s clk_tx0_p_s dl0_dft_hstx_data_lpbk_s<15> dl0_dft_hstx_data_lpbk_s<14> dl0_dft_hstx_data_lpbk_s<13> dl0_dft_hstx_data_lpbk_s<12> dl0_dft_hstx_data_lpbk_s<11> dl0_dft_hstx_data_lpbk_s<10>
+ dl0_dft_hstx_data_lpbk_s<9> dl0_dft_hstx_data_lpbk_s<8> dl0_dft_hstx_data_lpbk_s<7> dl0_dft_hstx_data_lpbk_s<6> dl0_dft_hstx_data_lpbk_s<5> dl0_dft_hstx_data_lpbk_s<4> dl0_dft_hstx_data_lpbk_s<3> dl0_dft_hstx_data_lpbk_s<2> dl0_dft_hstx_data_lpbk_s<1>
+ dl0_dft_hstx_data_lpbk_s<0> dft_dec_s<0> dft_tx0_hstx_ldo_monitor_vout_s dl0_dft_hstx_lower_path_en_s dft_dec_s<5> dft_tx0_lptx_ldo_monitor_vout_s dl0_dft_ser_test_in_en_s dl0_dft_ser_test_n_s dl0_dft_ser_test_p_s dft_dphy_ocdldo_res_dis_s dphy_pwrdn_s
+ dphy_reset_n_s dl0_dft_deser_en_s dl0_hs_ser_en_s hs_ser_msb_first_en_s hstx_lower_imp_cal_s<2> hstx_lower_imp_cal_s<1> hstx_lower_imp_cal_s<0> hstx_upper_imp_cal_s<2> hstx_upper_imp_cal_s<1> hstx_upper_imp_cal_s<0> dl0_hstx_data_s<15> dl0_hstx_data_s<14>
+ dl0_hstx_data_s<13> dl0_hstx_data_s<12> dl0_hstx_data_s<11> dl0_hstx_data_s<10> dl0_hstx_data_s<9> dl0_hstx_data_s<8> dl0_hstx_data_s<7> dl0_hstx_data_s<6> dl0_hstx_data_s<5> dl0_hstx_data_s<4> dl0_hstx_data_s<3> dl0_hstx_data_s<2> dl0_hstx_data_s<1>
+ dl0_hstx_data_s<0> hstx_en_fast_trf_s dl0_hstx_en_lptx_dis_s hstx_ldo_vref_as dl0_hstx_pwrdn_s v_ibias_s<0> v_ibias_s<1> dl0_lptx_dn_s dl0_lptx_dp_s dl0_lptx_en_s lptx_ldo_vref_as lptx_vref_prog_s<4> lptx_vref_prog_s<3> lptx_vref_prog_s<2> lptx_vref_prog_s<1>
+ lptx_vref_prog_s<0> tx_data_0_n_o tx_data_0_p_o dl0_delay_prog_s<2> dl0_delay_prog_s<1> dl0_delay_prog_s<0> inh_bulk_n inh_bulk_p phy_lane
  Xtx3 VDDPHY1V5 GNDPHY dl3_bypass_delay_line_s net0509 clk_tx3_n_s clk_tx3_p_s dl3_dft_hstx_data_lpbk_s<15> dl3_dft_hstx_data_lpbk_s<14> dl3_dft_hstx_data_lpbk_s<13> dl3_dft_hstx_data_lpbk_s<12> dl3_dft_hstx_data_lpbk_s<11> dl3_dft_hstx_data_lpbk_s<10>
+ dl3_dft_hstx_data_lpbk_s<9> dl3_dft_hstx_data_lpbk_s<8> dl3_dft_hstx_data_lpbk_s<7> dl3_dft_hstx_data_lpbk_s<6> dl3_dft_hstx_data_lpbk_s<5> dl3_dft_hstx_data_lpbk_s<4> dl3_dft_hstx_data_lpbk_s<3> dl3_dft_hstx_data_lpbk_s<2> dl3_dft_hstx_data_lpbk_s<1>
+ dl3_dft_hstx_data_lpbk_s<0> dft_dec_s<4> dft_tx3_hstx_ldo_monitor_vout_s dl3_dft_hstx_lower_path_en_s dft_dec_s<9> dft_tx3_lptx_ldo_monitor_vout_s dl3_dft_ser_test_in_en_s dl3_dft_ser_test_n_s dl3_dft_ser_test_p_s dft_dphy_ocdldo_res_dis_s dphy_pwrdn_s
+ dphy_reset_n_s dl3_dft_deser_en_s dl3_hs_ser_en_s hs_ser_msb_first_en_s hstx_lower_imp_cal_s<2> hstx_lower_imp_cal_s<1> hstx_lower_imp_cal_s<0> hstx_upper_imp_cal_s<2> hstx_upper_imp_cal_s<1> hstx_upper_imp_cal_s<0> dl3_hstx_data_s<15> dl3_hstx_data_s<14>
+ dl3_hstx_data_s<13> dl3_hstx_data_s<12> dl3_hstx_data_s<11> dl3_hstx_data_s<10> dl3_hstx_data_s<9> dl3_hstx_data_s<8> dl3_hstx_data_s<7> dl3_hstx_data_s<6> dl3_hstx_data_s<5> dl3_hstx_data_s<4> dl3_hstx_data_s<3> dl3_hstx_data_s<2> dl3_hstx_data_s<1>
+ dl3_hstx_data_s<0> hstx_en_fast_trf_s dl3_hstx_en_lptx_dis_s hstx_ldo_vref_as dl3_hstx_pwrdn_s v_ibias_s<8> v_ibias_s<9> dl3_lptx_dn_s dl3_lptx_dp_s dl3_lptx_en_s lptx_ldo_vref_as lptx_vref_prog_s<4> lptx_vref_prog_s<3> lptx_vref_prog_s<2> lptx_vref_prog_s<1>
+ lptx_vref_prog_s<0> tx_data_3_n_o tx_data_3_p_o dl3_delay_prog_s<2> dl3_delay_prog_s<1> dl3_delay_prog_s<0> inh_bulk_n inh_bulk_p phy_lane
  Xtx2 VDDPHY1V5 GNDPHY dl2_bypass_delay_line_s net0294 clk_tx2_n_s clk_tx2_p_s dl2_dft_hstx_data_lpbk_s<15> dl2_dft_hstx_data_lpbk_s<14> dl2_dft_hstx_data_lpbk_s<13> dl2_dft_hstx_data_lpbk_s<12> dl2_dft_hstx_data_lpbk_s<11> dl2_dft_hstx_data_lpbk_s<10>
+ dl2_dft_hstx_data_lpbk_s<9> dl2_dft_hstx_data_lpbk_s<8> dl2_dft_hstx_data_lpbk_s<7> dl2_dft_hstx_data_lpbk_s<6> dl2_dft_hstx_data_lpbk_s<5> dl2_dft_hstx_data_lpbk_s<4> dl2_dft_hstx_data_lpbk_s<3> dl2_dft_hstx_data_lpbk_s<2> dl2_dft_hstx_data_lpbk_s<1>
+ dl2_dft_hstx_data_lpbk_s<0> dft_dec_s<3> dft_tx2_hstx_ldo_monitor_vout_s dl2_dft_hstx_lower_path_en_s dft_dec_s<8> dft_tx2_lptx_ldo_monitor_vout_s dl2_dft_ser_test_in_en_s dl2_dft_ser_test_n_s dl2_dft_ser_test_p_s dft_dphy_ocdldo_res_dis_s dphy_pwrdn_s
+ dphy_reset_n_s dl2_dft_deser_en_s dl2_hs_ser_en_s hs_ser_msb_first_en_s hstx_lower_imp_cal_s<2> hstx_lower_imp_cal_s<1> hstx_lower_imp_cal_s<0> hstx_upper_imp_cal_s<2> hstx_upper_imp_cal_s<1> hstx_upper_imp_cal_s<0> dl2_hstx_data_s<15> dl2_hstx_data_s<14>
+ dl2_hstx_data_s<13> dl2_hstx_data_s<12> dl2_hstx_data_s<11> dl2_hstx_data_s<10> dl2_hstx_data_s<9> dl2_hstx_data_s<8> dl2_hstx_data_s<7> dl2_hstx_data_s<6> dl2_hstx_data_s<5> dl2_hstx_data_s<4> dl2_hstx_data_s<3> dl2_hstx_data_s<2> dl2_hstx_data_s<1>
+ dl2_hstx_data_s<0> hstx_en_fast_trf_s dl2_hstx_en_lptx_dis_s hstx_ldo_vref_as dl2_hstx_pwrdn_s v_ibias_s<6> v_ibias_s<7> dl2_lptx_dn_s dl2_lptx_dp_s dl2_lptx_en_s lptx_ldo_vref_as lptx_vref_prog_s<4> lptx_vref_prog_s<3> lptx_vref_prog_s<2> lptx_vref_prog_s<1>
+ lptx_vref_prog_s<0> tx_data_2_n_o tx_data_2_p_o dl2_delay_prog_s<2> dl2_delay_prog_s<1> dl2_delay_prog_s<0> inh_bulk_n inh_bulk_p phy_lane
  Xtx1 VDDPHY1V5 GNDPHY dl1_bypass_delay_line_s clk_byte_s clk_tx1_n_s clk_tx1_p_s dl1_dft_hstx_data_lpbk_s<15> dl1_dft_hstx_data_lpbk_s<14> dl1_dft_hstx_data_lpbk_s<13> dl1_dft_hstx_data_lpbk_s<12> dl1_dft_hstx_data_lpbk_s<11> dl1_dft_hstx_data_lpbk_s<10>
+ dl1_dft_hstx_data_lpbk_s<9> dl1_dft_hstx_data_lpbk_s<8> dl1_dft_hstx_data_lpbk_s<7> dl1_dft_hstx_data_lpbk_s<6> dl1_dft_hstx_data_lpbk_s<5> dl1_dft_hstx_data_lpbk_s<4> dl1_dft_hstx_data_lpbk_s<3> dl1_dft_hstx_data_lpbk_s<2> dl1_dft_hstx_data_lpbk_s<1>
+ dl1_dft_hstx_data_lpbk_s<0> dft_dec_s<1> dft_tx1_hstx_ldo_monitor_vout_s dl1_dft_hstx_lower_path_en_s dft_dec_s<6> dft_tx1_lptx_ldo_monitor_vout_s dl1_dft_ser_test_in_en_s dl1_dft_ser_test_n_s dftmux_b_s dft_dphy_ocdldo_res_dis_s dphy_pwrdn_s dphy_reset_n_s
+ dl1_dft_deser_en_s dl1_hs_ser_en_s hs_ser_msb_first_en_s hstx_lower_imp_cal_s<2> hstx_lower_imp_cal_s<1> hstx_lower_imp_cal_s<0> hstx_upper_imp_cal_s<2> hstx_upper_imp_cal_s<1> hstx_upper_imp_cal_s<0> dl1_hstx_data_s<15> dl1_hstx_data_s<14> dl1_hstx_data_s<13>
+ dl1_hstx_data_s<12> dl1_hstx_data_s<11> dl1_hstx_data_s<10> dl1_hstx_data_s<9> dl1_hstx_data_s<8> dl1_hstx_data_s<7> dl1_hstx_data_s<6> dl1_hstx_data_s<5> dl1_hstx_data_s<4> dl1_hstx_data_s<3> dl1_hstx_data_s<2> dl1_hstx_data_s<1> dl1_hstx_data_s<0>
+ hstx_en_fast_trf_s dl1_hstx_en_lptx_dis_s hstx_ldo_vref_as dl1_hstx_pwrdn_s v_ibias_s<2> v_ibias_s<3> dl1_lptx_dn_s dl1_lptx_dp_s dl1_lptx_en_s lptx_ldo_vref_as lptx_vref_prog_s<4> lptx_vref_prog_s<3> lptx_vref_prog_s<2> lptx_vref_prog_s<1> lptx_vref_prog_s<0>
+ tx_data_1_n_o tx_data_1_p_o dl1_delay_prog_s<2> dl1_delay_prog_s<1> dl1_delay_prog_s<0> inh_bulk_n inh_bulk_p phy_lane
  XI276 ref_clk_dphy_i net0236 inh_bulk_n inh_bulk_p VDDPHY1V5 GNDPHY CLK6
  XI277 div_clk_dphy_i net0170 inh_bulk_n inh_bulk_p VDDPHY1V5 GNDPHY CLK6
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: CLKLO4
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT CLKLO4 CP CPEN EN inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mntrans119 CP1 CP inh_lSup inh_bulk_n NREG W='400n' L='120.0n' M='1'
  Mntrans162 net127 MB2 inh_lSup inh_bulk_n NREG W='400n' L='120.0n' M='1'
  MN5 CPEN2 MF1 inh_lSup inh_bulk_n NREG W='760.0n' L='120.0n' M='1'
  MN6 EN1 EN inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  MN7 MF1 CP1 EN1 inh_bulk_n NREG W='700n' L='120.0n' M='1'
  Mntrans123 CP2 CP1 inh_lSup inh_bulk_n NREG W='340.0n' L='120.0n' M='1'
  Mntrans136 MB2 MF1 inh_lSup inh_bulk_n NREG W='400n' L='120.0n' M='1'
  Mntrans161 MF1 CP2 net127 inh_bulk_n NREG W='400n' L='120.0n' M='1'
  Mntrans22 CPEN CPEN1 inh_lSup inh_bulk_n NREG W='1.36u' L='120.0n' M='1'
  Mntrans21 CPEN1 CP net0130 inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  Mntrans20 net0130 CPEN2 inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  Mptrans118 CP1 CP inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  Mptrans163 MF1 CP1 net98 inh_bulk_p PREG W='600n' L='120.0n' M='1'
  Mptrans164 net98 MB2 inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  Mptrans25 CPEN CPEN1 inh_hSup inh_bulk_p PREG W='3.24u' L='120.0n' M='1'
  MP9 MF1 CP2 EN1 inh_bulk_p PREG W='700n' L='120.0n' M='1'
  MP8 EN1 EN inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  Mptrans122 CP2 CP1 inh_hSup inh_bulk_p PREG W='500n' L='120.0n' M='1'
  Mptrans135 MB2 MF1 inh_hSup inh_bulk_p PREG W='600n' L='120.0n' M='1'
  Mptrans24 CPEN1 CP inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  MP5 CPEN2 MF1 inh_hSup inh_bulk_p PREG W='1.08u' L='120.0n' M='1'
  Mptrans23 CPEN1 CPEN2 inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='1.71e-11'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: OR2V
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT OR2V A B Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mptrans24 net26 A net41 inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  Mptrans23 net41 B inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  Mptrans22 Z net26 inh_hSup inh_bulk_p PREG W='6.48u' L='120.0n' M='1'
  MP1 net26 A net035 inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  MP0 net035 B inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  MP5 net26 A net045 inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  MP4 net045 B inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  MP3 net26 A net051 inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  MP2 net051 B inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  Mntrans27 net26 A inh_lSup inh_bulk_n NREG W='3.36u' L='120.0n' M='1'
  Mntrans26 net26 B inh_lSup inh_bulk_n NREG W='3.36u' L='120.0n' M='1'
  Mntrans25 Z net26 inh_lSup inh_bulk_n NREG W='4.48u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='1.35e-11'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: BUF4
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT BUF4 A Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mptrans15 net24 A inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  Mptrans14 Z net24 inh_hSup inh_bulk_p PREG W='3.24u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='5.4e-12'
  Mntrans13 net24 A inh_lSup inh_bulk_n NREG W='1.12u' L='120.0n' M='1'
  Mntrans12 Z net24 inh_lSup inh_bulk_n NREG W='2.24u' L='120.0n' M='1'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: AND3B
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT AND3B A B C Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mntrans70 Z net49 inh_lSup inh_bulk_n NREG W='2.24u' L='120.0n' M='1'
  Mntrans69 net45 C inh_lSup inh_bulk_n NREG W='900n' L='120.0n' M='1'
  Mntrans68 net42 B net45 inh_bulk_n NREG W='900n' L='120.0n' M='1'
  Mntrans67 net49 A net42 inh_bulk_n NREG W='900n' L='120.0n' M='1'
  MN1 net042 B net039 inh_bulk_n NREG W='900n' L='120.0n' M='1'
  MN2 net039 C inh_lSup inh_bulk_n NREG W='900n' L='120.0n' M='1'
  MN0 net49 A net042 inh_bulk_n NREG W='900n' L='120.0n' M='1'
  Mptrans74 Z net49 inh_hSup inh_bulk_p PREG W='3.24u' L='120.0n' M='1'
  Mptrans73 net49 C inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  Mptrans72 net49 A inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  Mptrans71 net49 B inh_hSup inh_bulk_p PREG W='1.62u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='9e-12'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: OR2I
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT OR2I A B Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mntrans11 net38 B inh_lSup inh_bulk_n NREG W='560.0n' L='120.0n' M='1'
  Mntrans36 net35 A inh_lSup inh_bulk_n NREG W='860.0n' L='120.0n' M='1'
  Mntrans35 Z net38 net35 inh_bulk_n NREG W='860.0n' L='120.0n' M='1'
  Mptrans10 net38 B inh_hSup inh_bulk_p PREG W='800n' L='120.0n' M='1'
  Mptrans38 Z A inh_hSup inh_bulk_p PREG W='860.0n' L='120.0n' M='1'
  Mptrans37 Z net38 inh_hSup inh_bulk_p PREG W='860.0n' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='4.5e-12'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: dig_lib
** Cell name: BUF12
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT BUF12 A Z inh_bulk_n inh_bulk_p inh_hSup inh_lSup
  Mptrans15 net24 A inh_hSup inh_bulk_p PREG W='4.86u' L='120.0n' M='1'
  Mptrans14 Z net24 inh_hSup inh_bulk_p PREG W='9.72u' L='120.0n' M='1'
  XINSTANCE1 inh_lSup inh_hSup inh_bulk_n DIODE_X AREA='1.17e-11'
  Mntrans13 net24 A inh_lSup inh_bulk_n NREG W='3.36u' L='120.0n' M='1'
  Mntrans12 Z net24 inh_lSup inh_bulk_n NREG W='6.72u' L='120.0n' M='1'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_ana_sts
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_ana_sts VDD VSS cl_bypass_delay_line_i cl_bypass_delay_line_o cl_delay_prog_i<2> cl_delay_prog_i<1> cl_delay_prog_i<0> cl_delay_prog_o<2> cl_delay_prog_o<1> cl_delay_prog_o<0> cl_dft_deser_en_i cl_dft_deser_en_o cl_dft_hstx_data_lpbk_i<15>
+ cl_dft_hstx_data_lpbk_i<14> cl_dft_hstx_data_lpbk_i<13> cl_dft_hstx_data_lpbk_i<12> cl_dft_hstx_data_lpbk_i<11> cl_dft_hstx_data_lpbk_i<10> cl_dft_hstx_data_lpbk_i<9> cl_dft_hstx_data_lpbk_i<8> cl_dft_hstx_data_lpbk_i<7> cl_dft_hstx_data_lpbk_i<6>
+ cl_dft_hstx_data_lpbk_i<5> cl_dft_hstx_data_lpbk_i<4> cl_dft_hstx_data_lpbk_i<3> cl_dft_hstx_data_lpbk_i<2> cl_dft_hstx_data_lpbk_i<1> cl_dft_hstx_data_lpbk_i<0> cl_dft_hstx_data_lpbk_o<15> cl_dft_hstx_data_lpbk_o<14> cl_dft_hstx_data_lpbk_o<13>
+ cl_dft_hstx_data_lpbk_o<12> cl_dft_hstx_data_lpbk_o<11> cl_dft_hstx_data_lpbk_o<10> cl_dft_hstx_data_lpbk_o<9> cl_dft_hstx_data_lpbk_o<8> cl_dft_hstx_data_lpbk_o<7> cl_dft_hstx_data_lpbk_o<6> cl_dft_hstx_data_lpbk_o<5> cl_dft_hstx_data_lpbk_o<4>
+ cl_dft_hstx_data_lpbk_o<3> cl_dft_hstx_data_lpbk_o<2> cl_dft_hstx_data_lpbk_o<1> cl_dft_hstx_data_lpbk_o<0> cl_dft_hstx_higher_path_en_i cl_dft_hstx_lower_path_en_i cl_dft_hstx_lower_path_en_o cl_dft_ser_test_in_en_i cl_dft_ser_test_in_en_o cl_dft_ser_test_n_i
+ cl_dft_ser_test_n_o cl_dft_ser_test_p_i cl_dft_ser_test_p_o cl_hs_ser_en_i cl_hs_ser_en_o cl_hstx_data_i<15> cl_hstx_data_i<14> cl_hstx_data_i<13> cl_hstx_data_i<12> cl_hstx_data_i<11> cl_hstx_data_i<10> cl_hstx_data_i<9> cl_hstx_data_i<8> cl_hstx_data_i<7>
+ cl_hstx_data_i<6> cl_hstx_data_i<5> cl_hstx_data_i<4> cl_hstx_data_i<3> cl_hstx_data_i<2> cl_hstx_data_i<1> cl_hstx_data_i<0> cl_hstx_data_o<15> cl_hstx_data_o<14> cl_hstx_data_o<13> cl_hstx_data_o<12> cl_hstx_data_o<11> cl_hstx_data_o<10> cl_hstx_data_o<9>
+ cl_hstx_data_o<8> cl_hstx_data_o<7> cl_hstx_data_o<6> cl_hstx_data_o<5> cl_hstx_data_o<4> cl_hstx_data_o<3> cl_hstx_data_o<2> cl_hstx_data_o<1> cl_hstx_data_o<0> cl_hstx_en_lptx_dis_i cl_hstx_en_lptx_dis_o cl_hstx_pwrdn_i cl_hstx_pwrdn_o cl_lptx_dn_i
+ cl_lptx_dn_o cl_lptx_dp_i cl_lptx_dp_o cl_lptx_en_i cl_lptx_en_o clk_byte_i clk_byte_o dft_ana_test_en_i dft_ana_test_en_o dft_ana_test_out_dphy_sel_i<3> dft_ana_test_out_dphy_sel_i<2> dft_ana_test_out_dphy_sel_i<1> dft_ana_test_out_dphy_sel_i<0>
+ dft_ana_test_out_dphy_sel_o<3> dft_ana_test_out_dphy_sel_o<2> dft_ana_test_out_dphy_sel_o<1> dft_ana_test_out_dphy_sel_o<0> dft_dphy_ocdldo_res_dis_i dft_dphy_ocdldo_res_dis_o dft_pll_clks_2_cl_en_i dft_pll_clks_2_cl_en_o dft_scan_mode_i dl0_bypass_delay_line_i
+ dl0_bypass_delay_line_o dl0_delay_prog_i<2> dl0_delay_prog_i<1> dl0_delay_prog_i<0> dl0_delay_prog_o<2> dl0_delay_prog_o<1> dl0_delay_prog_o<0> dl0_dft_deser_en_i dl0_dft_deser_en_o dl0_dft_hstx_data_lpbk_i<15> dl0_dft_hstx_data_lpbk_i<14>
+ dl0_dft_hstx_data_lpbk_i<13> dl0_dft_hstx_data_lpbk_i<12> dl0_dft_hstx_data_lpbk_i<11> dl0_dft_hstx_data_lpbk_i<10> dl0_dft_hstx_data_lpbk_i<9> dl0_dft_hstx_data_lpbk_i<8> dl0_dft_hstx_data_lpbk_i<7> dl0_dft_hstx_data_lpbk_i<6> dl0_dft_hstx_data_lpbk_i<5>
+ dl0_dft_hstx_data_lpbk_i<4> dl0_dft_hstx_data_lpbk_i<3> dl0_dft_hstx_data_lpbk_i<2> dl0_dft_hstx_data_lpbk_i<1> dl0_dft_hstx_data_lpbk_i<0> dl0_dft_hstx_data_lpbk_o<15> dl0_dft_hstx_data_lpbk_o<14> dl0_dft_hstx_data_lpbk_o<13> dl0_dft_hstx_data_lpbk_o<12>
+ dl0_dft_hstx_data_lpbk_o<11> dl0_dft_hstx_data_lpbk_o<10> dl0_dft_hstx_data_lpbk_o<9> dl0_dft_hstx_data_lpbk_o<8> dl0_dft_hstx_data_lpbk_o<7> dl0_dft_hstx_data_lpbk_o<6> dl0_dft_hstx_data_lpbk_o<5> dl0_dft_hstx_data_lpbk_o<4> dl0_dft_hstx_data_lpbk_o<3>
+ dl0_dft_hstx_data_lpbk_o<2> dl0_dft_hstx_data_lpbk_o<1> dl0_dft_hstx_data_lpbk_o<0> dl0_dft_hstx_higher_path_en_i dl0_dft_hstx_lower_path_en_i dl0_dft_hstx_lower_path_en_o dl0_dft_ser_test_in_en_i dl0_dft_ser_test_in_en_o dl0_dft_ser_test_n_i
+ dl0_dft_ser_test_n_o dl0_dft_ser_test_p_i dl0_dft_ser_test_p_o dl0_hs_ser_en_i dl0_hs_ser_en_o dl0_hstx_data_i<15> dl0_hstx_data_i<14> dl0_hstx_data_i<13> dl0_hstx_data_i<12> dl0_hstx_data_i<11> dl0_hstx_data_i<10> dl0_hstx_data_i<9> dl0_hstx_data_i<8>
+ dl0_hstx_data_i<7> dl0_hstx_data_i<6> dl0_hstx_data_i<5> dl0_hstx_data_i<4> dl0_hstx_data_i<3> dl0_hstx_data_i<2> dl0_hstx_data_i<1> dl0_hstx_data_i<0> dl0_hstx_data_o<15> dl0_hstx_data_o<14> dl0_hstx_data_o<13> dl0_hstx_data_o<12> dl0_hstx_data_o<11>
+ dl0_hstx_data_o<10> dl0_hstx_data_o<9> dl0_hstx_data_o<8> dl0_hstx_data_o<7> dl0_hstx_data_o<6> dl0_hstx_data_o<5> dl0_hstx_data_o<4> dl0_hstx_data_o<3> dl0_hstx_data_o<2> dl0_hstx_data_o<1> dl0_hstx_data_o<0> dl0_hstx_en_lptx_dis_i dl0_hstx_en_lptx_dis_o
+ dl0_hstx_pwrdn_i dl0_hstx_pwrdn_o dl0_lptx_dn_i dl0_lptx_dn_o dl0_lptx_dp_i dl0_lptx_dp_o dl0_lptx_en_i dl0_lptx_en_o dl1_bypass_delay_line_i dl1_bypass_delay_line_o dl1_delay_prog_i<2> dl1_delay_prog_i<1> dl1_delay_prog_i<0> dl1_delay_prog_o<2>
+ dl1_delay_prog_o<1> dl1_delay_prog_o<0> dl1_dft_deser_en_i dl1_dft_deser_en_o dl1_dft_hstx_data_lpbk_i<15> dl1_dft_hstx_data_lpbk_i<14> dl1_dft_hstx_data_lpbk_i<13> dl1_dft_hstx_data_lpbk_i<12> dl1_dft_hstx_data_lpbk_i<11> dl1_dft_hstx_data_lpbk_i<10>
+ dl1_dft_hstx_data_lpbk_i<9> dl1_dft_hstx_data_lpbk_i<8> dl1_dft_hstx_data_lpbk_i<7> dl1_dft_hstx_data_lpbk_i<6> dl1_dft_hstx_data_lpbk_i<5> dl1_dft_hstx_data_lpbk_i<4> dl1_dft_hstx_data_lpbk_i<3> dl1_dft_hstx_data_lpbk_i<2> dl1_dft_hstx_data_lpbk_i<1>
+ dl1_dft_hstx_data_lpbk_i<0> dl1_dft_hstx_data_lpbk_o<15> dl1_dft_hstx_data_lpbk_o<14> dl1_dft_hstx_data_lpbk_o<13> dl1_dft_hstx_data_lpbk_o<12> dl1_dft_hstx_data_lpbk_o<11> dl1_dft_hstx_data_lpbk_o<10> dl1_dft_hstx_data_lpbk_o<9> dl1_dft_hstx_data_lpbk_o<8>
+ dl1_dft_hstx_data_lpbk_o<7> dl1_dft_hstx_data_lpbk_o<6> dl1_dft_hstx_data_lpbk_o<5> dl1_dft_hstx_data_lpbk_o<4> dl1_dft_hstx_data_lpbk_o<3> dl1_dft_hstx_data_lpbk_o<2> dl1_dft_hstx_data_lpbk_o<1> dl1_dft_hstx_data_lpbk_o<0> dl1_dft_hstx_higher_path_en_i
+ dl1_dft_hstx_lower_path_en_i dl1_dft_hstx_lower_path_en_o dl1_dft_ser_test_in_en_i dl1_dft_ser_test_in_en_o dl1_dft_ser_test_n_i dl1_dft_ser_test_n_o dl1_dft_ser_test_p_i dl1_dft_ser_test_p_o dl1_hs_ser_en_i dl1_hs_ser_en_o dl1_hstx_data_i<15>
+ dl1_hstx_data_i<14> dl1_hstx_data_i<13> dl1_hstx_data_i<12> dl1_hstx_data_i<11> dl1_hstx_data_i<10> dl1_hstx_data_i<9> dl1_hstx_data_i<8> dl1_hstx_data_i<7> dl1_hstx_data_i<6> dl1_hstx_data_i<5> dl1_hstx_data_i<4> dl1_hstx_data_i<3> dl1_hstx_data_i<2>
+ dl1_hstx_data_i<1> dl1_hstx_data_i<0> dl1_hstx_data_o<15> dl1_hstx_data_o<14> dl1_hstx_data_o<13> dl1_hstx_data_o<12> dl1_hstx_data_o<11> dl1_hstx_data_o<10> dl1_hstx_data_o<9> dl1_hstx_data_o<8> dl1_hstx_data_o<7> dl1_hstx_data_o<6> dl1_hstx_data_o<5>
+ dl1_hstx_data_o<4> dl1_hstx_data_o<3> dl1_hstx_data_o<2> dl1_hstx_data_o<1> dl1_hstx_data_o<0> dl1_hstx_en_lptx_dis_i dl1_hstx_en_lptx_dis_o dl1_hstx_pwrdn_i dl1_hstx_pwrdn_o dl1_lptx_dn_i dl1_lptx_dn_o dl1_lptx_dp_i dl1_lptx_dp_o dl1_lptx_en_i dl1_lptx_en_o
+ dl2_bypass_delay_line_i dl2_bypass_delay_line_o dl2_delay_prog_i<2> dl2_delay_prog_i<1> dl2_delay_prog_i<0> dl2_delay_prog_o<2> dl2_delay_prog_o<1> dl2_delay_prog_o<0> dl2_dft_deser_en_i dl2_dft_deser_en_o dl2_dft_hstx_data_lpbk_i<15>
+ dl2_dft_hstx_data_lpbk_i<14> dl2_dft_hstx_data_lpbk_i<13> dl2_dft_hstx_data_lpbk_i<12> dl2_dft_hstx_data_lpbk_i<11> dl2_dft_hstx_data_lpbk_i<10> dl2_dft_hstx_data_lpbk_i<9> dl2_dft_hstx_data_lpbk_i<8> dl2_dft_hstx_data_lpbk_i<7> dl2_dft_hstx_data_lpbk_i<6>
+ dl2_dft_hstx_data_lpbk_i<5> dl2_dft_hstx_data_lpbk_i<4> dl2_dft_hstx_data_lpbk_i<3> dl2_dft_hstx_data_lpbk_i<2> dl2_dft_hstx_data_lpbk_i<1> dl2_dft_hstx_data_lpbk_i<0> dl2_dft_hstx_data_lpbk_o<15> dl2_dft_hstx_data_lpbk_o<14> dl2_dft_hstx_data_lpbk_o<13>
+ dl2_dft_hstx_data_lpbk_o<12> dl2_dft_hstx_data_lpbk_o<11> dl2_dft_hstx_data_lpbk_o<10> dl2_dft_hstx_data_lpbk_o<9> dl2_dft_hstx_data_lpbk_o<8> dl2_dft_hstx_data_lpbk_o<7> dl2_dft_hstx_data_lpbk_o<6> dl2_dft_hstx_data_lpbk_o<5> dl2_dft_hstx_data_lpbk_o<4>
+ dl2_dft_hstx_data_lpbk_o<3> dl2_dft_hstx_data_lpbk_o<2> dl2_dft_hstx_data_lpbk_o<1> dl2_dft_hstx_data_lpbk_o<0> dl2_dft_hstx_higher_path_en_i dl2_dft_hstx_lower_path_en_i dl2_dft_hstx_lower_path_en_o dl2_dft_ser_test_in_en_i dl2_dft_ser_test_in_en_o
+ dl2_dft_ser_test_n_i dl2_dft_ser_test_n_o dl2_dft_ser_test_p_i dl2_dft_ser_test_p_o dl2_hs_ser_en_i dl2_hs_ser_en_o dl2_hstx_data_i<15> dl2_hstx_data_i<14> dl2_hstx_data_i<13> dl2_hstx_data_i<12> dl2_hstx_data_i<11> dl2_hstx_data_i<10> dl2_hstx_data_i<9>
+ dl2_hstx_data_i<8> dl2_hstx_data_i<7> dl2_hstx_data_i<6> dl2_hstx_data_i<5> dl2_hstx_data_i<4> dl2_hstx_data_i<3> dl2_hstx_data_i<2> dl2_hstx_data_i<1> dl2_hstx_data_i<0> dl2_hstx_data_o<15> dl2_hstx_data_o<14> dl2_hstx_data_o<13> dl2_hstx_data_o<12>
+ dl2_hstx_data_o<11> dl2_hstx_data_o<10> dl2_hstx_data_o<9> dl2_hstx_data_o<8> dl2_hstx_data_o<7> dl2_hstx_data_o<6> dl2_hstx_data_o<5> dl2_hstx_data_o<4> dl2_hstx_data_o<3> dl2_hstx_data_o<2> dl2_hstx_data_o<1> dl2_hstx_data_o<0> dl2_hstx_en_lptx_dis_i
+ dl2_hstx_en_lptx_dis_o dl2_hstx_pwrdn_i dl2_hstx_pwrdn_o dl2_lptx_dn_i dl2_lptx_dn_o dl2_lptx_dp_i dl2_lptx_dp_o dl2_lptx_en_i dl2_lptx_en_o dl3_bypass_delay_line_i dl3_bypass_delay_line_o dl3_delay_prog_i<2> dl3_delay_prog_i<1> dl3_delay_prog_i<0>
+ dl3_delay_prog_o<2> dl3_delay_prog_o<1> dl3_delay_prog_o<0> dl3_dft_deser_en_i dl3_dft_deser_en_o dl3_dft_hstx_data_lpbk_i<15> dl3_dft_hstx_data_lpbk_i<14> dl3_dft_hstx_data_lpbk_i<13> dl3_dft_hstx_data_lpbk_i<12> dl3_dft_hstx_data_lpbk_i<11>
+ dl3_dft_hstx_data_lpbk_i<10> dl3_dft_hstx_data_lpbk_i<9> dl3_dft_hstx_data_lpbk_i<8> dl3_dft_hstx_data_lpbk_i<7> dl3_dft_hstx_data_lpbk_i<6> dl3_dft_hstx_data_lpbk_i<5> dl3_dft_hstx_data_lpbk_i<4> dl3_dft_hstx_data_lpbk_i<3> dl3_dft_hstx_data_lpbk_i<2>
+ dl3_dft_hstx_data_lpbk_i<1> dl3_dft_hstx_data_lpbk_i<0> dl3_dft_hstx_data_lpbk_o<15> dl3_dft_hstx_data_lpbk_o<14> dl3_dft_hstx_data_lpbk_o<13> dl3_dft_hstx_data_lpbk_o<12> dl3_dft_hstx_data_lpbk_o<11> dl3_dft_hstx_data_lpbk_o<10> dl3_dft_hstx_data_lpbk_o<9>
+ dl3_dft_hstx_data_lpbk_o<8> dl3_dft_hstx_data_lpbk_o<7> dl3_dft_hstx_data_lpbk_o<6> dl3_dft_hstx_data_lpbk_o<5> dl3_dft_hstx_data_lpbk_o<4> dl3_dft_hstx_data_lpbk_o<3> dl3_dft_hstx_data_lpbk_o<2> dl3_dft_hstx_data_lpbk_o<1> dl3_dft_hstx_data_lpbk_o<0>
+ dl3_dft_hstx_higher_path_en_i dl3_dft_hstx_lower_path_en_i dl3_dft_hstx_lower_path_en_o dl3_dft_ser_test_in_en_i dl3_dft_ser_test_in_en_o dl3_dft_ser_test_n_i dl3_dft_ser_test_n_o dl3_dft_ser_test_p_i dl3_dft_ser_test_p_o dl3_hs_ser_en_i dl3_hs_ser_en_o
+ dl3_hstx_data_i<15> dl3_hstx_data_i<14> dl3_hstx_data_i<13> dl3_hstx_data_i<12> dl3_hstx_data_i<11> dl3_hstx_data_i<10> dl3_hstx_data_i<9> dl3_hstx_data_i<8> dl3_hstx_data_i<7> dl3_hstx_data_i<6> dl3_hstx_data_i<5> dl3_hstx_data_i<4> dl3_hstx_data_i<3>
+ dl3_hstx_data_i<2> dl3_hstx_data_i<1> dl3_hstx_data_i<0> dl3_hstx_data_o<15> dl3_hstx_data_o<14> dl3_hstx_data_o<13> dl3_hstx_data_o<12> dl3_hstx_data_o<11> dl3_hstx_data_o<10> dl3_hstx_data_o<9> dl3_hstx_data_o<8> dl3_hstx_data_o<7> dl3_hstx_data_o<6>
+ dl3_hstx_data_o<5> dl3_hstx_data_o<4> dl3_hstx_data_o<3> dl3_hstx_data_o<2> dl3_hstx_data_o<1> dl3_hstx_data_o<0> dl3_hstx_en_lptx_dis_i dl3_hstx_en_lptx_dis_o dl3_hstx_pwrdn_i dl3_hstx_pwrdn_o dl3_lptx_dn_i dl3_lptx_dn_o dl3_lptx_dp_i dl3_lptx_dp_o
+ dl3_lptx_en_i dl3_lptx_en_o dphy_pwrdn_i dphy_pwrdn_o dphy_reset_n_i dphy_reset_n_o en_clk_byte_i en_clk_dphy_i en_clk_dphy_o hs_ser_msb_first_en_i hs_ser_msb_first_en_o hstx_en_fast_trf_i hstx_en_fast_trf_o hstx_lower_imp_cal_i<2> hstx_lower_imp_cal_i<1>
+ hstx_lower_imp_cal_i<0> hstx_lower_imp_cal_o<2> hstx_lower_imp_cal_o<1> hstx_lower_imp_cal_o<0> hstx_upper_imp_cal_i<2> hstx_upper_imp_cal_i<1> hstx_upper_imp_cal_i<0> hstx_upper_imp_cal_o<2> hstx_upper_imp_cal_o<1> hstx_upper_imp_cal_o<0> lptx_vref_prog_i<4>
+ lptx_vref_prog_i<3> lptx_vref_prog_i<2> lptx_vref_prog_i<1> lptx_vref_prog_i<0> lptx_vref_prog_o<4> lptx_vref_prog_o<3> lptx_vref_prog_o<2> lptx_vref_prog_o<1> lptx_vref_prog_o<0> sel_dr_i sel_dr_o inh_bulk_n inh_bulk_p
  XI35 clk_byte_s clk_byte_o dl1_en_s inh_bulk_n inh_bulk_p VDD VSS CLKLO4
  XI153 pwd_s dl3_en_s inh_bulk_n inh_bulk_p VDD VSS INV24
  XI134 pwd_s dl2_en_s inh_bulk_n inh_bulk_p VDD VSS INV24
  XI115 pwd_s cl_en_s inh_bulk_n inh_bulk_p VDD VSS INV24
  XI96 pwd_s dl1_en_s inh_bulk_n inh_bulk_p VDD VSS INV24
  XI69 pwd_s dl0_en_s inh_bulk_n inh_bulk_p VDD VSS INV24
  XI36 pwd_s net0203 inh_bulk_n inh_bulk_p VDD VSS INV24
  XI206 pwd_s net0188 inh_bulk_n inh_bulk_p VDD VSS INV24
  XI32 dft_scan_mode_i dphy_pwrdn_i pwd_s inh_bulk_n inh_bulk_p VDD VSS OR2V
  XI215 net0218 en_clk_byte_i en_clk_byte_s net0263 inh_bulk_n inh_bulk_p VDD VSS SYNFD2
  XI149 net0266 dl3_en_s dl3_dft_ser_test_in_en_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI148 net0298 dl3_en_s dl3_dft_ser_test_n_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI147 net0259 dl3_en_s dl3_dft_ser_test_p_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI189 dft_ana_test_en_i net0203 dft_ana_test_en_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI182 net0270 dl3_en_s dl3_dft_deser_en_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI146 net0254 dl3_en_s dl3_hs_ser_en_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI142 net0251 dl3_en_s dl3_lptx_dn_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI140 net0243 dl3_en_s dl3_lptx_en_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI139 net0242 dl3_en_s dl3_bypass_delay_line_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI138<2> net0294<2> dl3_en_s dl3_delay_prog_o<2> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI138<1> net0294<1> dl3_en_s dl3_delay_prog_o<1> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI138<0> net0294<0> dl3_en_s dl3_delay_prog_o<0> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI130 net0360 dl2_en_s dl2_dft_ser_test_in_en_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI129 net0349 dl2_en_s dl2_dft_ser_test_n_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI128 net0328 dl2_en_s dl2_dft_ser_test_p_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI122 net0345 dl2_en_s dl2_lptx_dp_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI181 net0343 dl2_en_s dl2_dft_deser_en_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI127 net0356 dl2_en_s dl2_hs_ser_en_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI141 net0248 dl3_en_s dl3_lptx_dp_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI121 net0228 dl2_en_s dl2_lptx_en_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI120 net0344 dl2_en_s dl2_bypass_delay_line_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI119<2> net0313<2> dl2_en_s dl2_delay_prog_o<2> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI119<1> net0313<1> dl2_en_s dl2_delay_prog_o<1> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI119<0> net0313<0> dl2_en_s dl2_delay_prog_o<0> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI111 net0386 cl_en_s cl_dft_ser_test_in_en_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI110 net0389 cl_en_s cl_dft_ser_test_n_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI109 net0423 cl_en_s cl_dft_ser_test_p_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI123 net0326 dl2_en_s dl2_lptx_dn_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI188<2> hstx_lower_imp_cal_i<2> net0203 hstx_lower_imp_cal_o<2> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI188<1> hstx_lower_imp_cal_i<1> net0203 hstx_lower_imp_cal_o<1> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI188<0> hstx_lower_imp_cal_i<0> net0203 hstx_lower_imp_cal_o<0> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI180 dl0_dft_deser_en_i dl0_en_s dl0_dft_deser_en_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI108 net0411 cl_en_s cl_hs_ser_en_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI104 net0399 cl_en_s cl_lptx_dn_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI102 net0416 cl_en_s cl_lptx_en_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI101 net0397 cl_en_s cl_bypass_delay_line_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI100<2> net0352<2> cl_en_s cl_delay_prog_o<2> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI100<1> net0352<1> cl_en_s cl_delay_prog_o<1> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI100<0> net0352<0> cl_en_s cl_delay_prog_o<0> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI95 dl1_dft_ser_test_in_en_i dl1_en_s dl1_dft_ser_test_in_en_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI94 dl1_dft_ser_test_n_i dl1_en_s dl1_dft_ser_test_n_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI93 dl1_dft_ser_test_p_i dl1_en_s dl1_dft_ser_test_p_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI88 dl1_lptx_dn_i dl1_en_s dl1_lptx_dn_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI191<4> lptx_vref_prog_i<4> net0203 lptx_vref_prog_o<4> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI191<3> lptx_vref_prog_i<3> net0203 lptx_vref_prog_o<3> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI191<2> lptx_vref_prog_i<2> net0203 lptx_vref_prog_o<2> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI191<1> lptx_vref_prog_i<1> net0203 lptx_vref_prog_o<1> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI191<0> lptx_vref_prog_i<0> net0203 lptx_vref_prog_o<0> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI203 net0464 net0188 en_clk_dphy_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI179 dl1_dft_deser_en_i dl1_en_s dl1_dft_deser_en_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI87 dl1_lptx_dp_i dl1_en_s dl1_lptx_dp_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI103 net0417 cl_en_s cl_lptx_dp_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI86 dl1_lptx_en_i dl1_en_s dl1_lptx_en_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI85 dl1_bypass_delay_line_i dl1_en_s dl1_bypass_delay_line_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI84<2> dl1_delay_prog_i<2> dl1_en_s dl1_delay_prog_o<2> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI84<1> dl1_delay_prog_i<1> dl1_en_s dl1_delay_prog_o<1> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI84<0> dl1_delay_prog_i<0> dl1_en_s dl1_delay_prog_o<0> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI70<2> dl0_delay_prog_i<2> dl0_en_s dl0_delay_prog_o<2> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI70<1> dl0_delay_prog_i<1> dl0_en_s dl0_delay_prog_o<1> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI70<0> dl0_delay_prog_i<0> dl0_en_s dl0_delay_prog_o<0> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI68 dl0_dft_ser_test_in_en_i dl0_en_s dl0_dft_ser_test_in_en_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI67 dl0_dft_ser_test_n_i dl0_en_s dl0_dft_ser_test_n_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI66 dl0_dft_ser_test_p_i dl0_en_s dl0_dft_ser_test_p_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI61 dl0_lptx_dn_i dl0_en_s dl0_lptx_dn_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI190<3> dft_ana_test_out_dphy_sel_i<3> net0203 dft_ana_test_out_dphy_sel_o<3> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI190<2> dft_ana_test_out_dphy_sel_i<2> net0203 dft_ana_test_out_dphy_sel_o<2> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI190<1> dft_ana_test_out_dphy_sel_i<1> net0203 dft_ana_test_out_dphy_sel_o<1> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI190<0> dft_ana_test_out_dphy_sel_i<0> net0203 dft_ana_test_out_dphy_sel_o<0> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI187<2> hstx_upper_imp_cal_i<2> net0203 hstx_upper_imp_cal_o<2> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI187<1> hstx_upper_imp_cal_i<1> net0203 hstx_upper_imp_cal_o<1> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI187<0> hstx_upper_imp_cal_i<0> net0203 hstx_upper_imp_cal_o<0> inh_bulk_n inh_bulk_p VDD VSS AND2
  XI200 net0448 net0188 hstx_en_fast_trf_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI208 net0396 cl_en_s dft_dphy_ocdldo_res_dis_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI183 net0420 cl_en_s cl_dft_deser_en_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI58 dl0_bypass_delay_line_i dl0_en_s dl0_bypass_delay_line_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI59 dl0_lptx_en_i dl0_en_s dl0_lptx_en_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI92 dl1_hs_ser_en_i dl1_en_s dl1_hs_ser_en_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI60 dl0_lptx_dp_i dl0_en_s dl0_lptx_dp_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI201 net0428 net0188 sel_dr_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI207 net0371 cl_en_s hs_ser_msb_first_en_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI210 dft_pll_clks_2_cl_en_i cl_en_s dft_pll_clks_2_cl_en_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI65 dl0_hs_ser_en_i dl0_en_s dl0_hs_ser_en_o inh_bulk_n inh_bulk_p VDD VSS AND2
  XI177<15> net0240 net0385<15> dl3_hstx_data_o<15> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI177<14> net0240 net0385<14> dl3_hstx_data_o<14> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI177<13> net0240 net0385<13> dl3_hstx_data_o<13> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI177<12> net0240 net0385<12> dl3_hstx_data_o<12> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI177<11> net0240 net0385<11> dl3_hstx_data_o<11> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI177<10> net0240 net0385<10> dl3_hstx_data_o<10> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI177<9> net0240 net0385<9> dl3_hstx_data_o<9> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI177<8> net0240 net0385<8> dl3_hstx_data_o<8> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI177<7> net0240 net0385<7> dl3_hstx_data_o<7> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI177<6> net0240 net0385<6> dl3_hstx_data_o<6> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI177<5> net0240 net0385<5> dl3_hstx_data_o<5> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI177<4> net0240 net0385<4> dl3_hstx_data_o<4> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI177<3> net0240 net0385<3> dl3_hstx_data_o<3> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI177<2> net0240 net0385<2> dl3_hstx_data_o<2> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI177<1> net0240 net0385<1> dl3_hstx_data_o<1> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI177<0> net0240 net0385<0> dl3_hstx_data_o<0> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI175<15> net0204 net0369<15> dl2_hstx_data_o<15> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI175<14> net0204 net0369<14> dl2_hstx_data_o<14> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI175<13> net0204 net0369<13> dl2_hstx_data_o<13> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI175<12> net0204 net0369<12> dl2_hstx_data_o<12> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI175<11> net0204 net0369<11> dl2_hstx_data_o<11> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI175<10> net0204 net0369<10> dl2_hstx_data_o<10> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI175<9> net0204 net0369<9> dl2_hstx_data_o<9> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI175<8> net0204 net0369<8> dl2_hstx_data_o<8> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI175<7> net0204 net0369<7> dl2_hstx_data_o<7> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI175<6> net0204 net0369<6> dl2_hstx_data_o<6> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI175<5> net0204 net0369<5> dl2_hstx_data_o<5> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI175<4> net0204 net0369<4> dl2_hstx_data_o<4> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI175<3> net0204 net0369<3> dl2_hstx_data_o<3> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI175<2> net0204 net0369<2> dl2_hstx_data_o<2> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI175<1> net0204 net0369<1> dl2_hstx_data_o<1> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI175<0> net0204 net0369<0> dl2_hstx_data_o<0> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI173<15> net0168 net0463<15> cl_hstx_data_o<15> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI173<14> net0168 net0463<14> cl_hstx_data_o<14> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI173<13> net0168 net0463<13> cl_hstx_data_o<13> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI173<12> net0168 net0463<12> cl_hstx_data_o<12> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI173<11> net0168 net0463<11> cl_hstx_data_o<11> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI173<10> net0168 net0463<10> cl_hstx_data_o<10> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI173<9> net0168 net0463<9> cl_hstx_data_o<9> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI173<8> net0168 net0463<8> cl_hstx_data_o<8> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI173<7> net0168 net0463<7> cl_hstx_data_o<7> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI173<6> net0168 net0463<6> cl_hstx_data_o<6> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI173<5> net0168 net0463<5> cl_hstx_data_o<5> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI173<4> net0168 net0463<4> cl_hstx_data_o<4> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI173<3> net0168 net0463<3> cl_hstx_data_o<3> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI173<2> net0168 net0463<2> cl_hstx_data_o<2> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI173<1> net0168 net0463<1> cl_hstx_data_o<1> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI173<0> net0168 net0463<0> cl_hstx_data_o<0> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI71<15> net099 dl0_hstx_data_i<15> dl0_hstx_data_o<15> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI71<14> net099 dl0_hstx_data_i<14> dl0_hstx_data_o<14> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI71<13> net099 dl0_hstx_data_i<13> dl0_hstx_data_o<13> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI71<12> net099 dl0_hstx_data_i<12> dl0_hstx_data_o<12> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI71<11> net099 dl0_hstx_data_i<11> dl0_hstx_data_o<11> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI71<10> net099 dl0_hstx_data_i<10> dl0_hstx_data_o<10> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI71<9> net099 dl0_hstx_data_i<9> dl0_hstx_data_o<9> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI71<8> net099 dl0_hstx_data_i<8> dl0_hstx_data_o<8> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI71<7> net099 dl0_hstx_data_i<7> dl0_hstx_data_o<7> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI71<6> net099 dl0_hstx_data_i<6> dl0_hstx_data_o<6> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI71<5> net099 dl0_hstx_data_i<5> dl0_hstx_data_o<5> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI71<4> net099 dl0_hstx_data_i<4> dl0_hstx_data_o<4> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI71<3> net099 dl0_hstx_data_i<3> dl0_hstx_data_o<3> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI71<2> net099 dl0_hstx_data_i<2> dl0_hstx_data_o<2> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI71<1> net099 dl0_hstx_data_i<1> dl0_hstx_data_o<1> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI71<0> net099 dl0_hstx_data_i<0> dl0_hstx_data_o<0> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI172<15> net0132 dl1_hstx_data_i<15> dl1_hstx_data_o<15> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI172<14> net0132 dl1_hstx_data_i<14> dl1_hstx_data_o<14> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI172<13> net0132 dl1_hstx_data_i<13> dl1_hstx_data_o<13> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI172<12> net0132 dl1_hstx_data_i<12> dl1_hstx_data_o<12> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI172<11> net0132 dl1_hstx_data_i<11> dl1_hstx_data_o<11> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI172<10> net0132 dl1_hstx_data_i<10> dl1_hstx_data_o<10> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI172<9> net0132 dl1_hstx_data_i<9> dl1_hstx_data_o<9> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI172<8> net0132 dl1_hstx_data_i<8> dl1_hstx_data_o<8> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI172<7> net0132 dl1_hstx_data_i<7> dl1_hstx_data_o<7> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI172<6> net0132 dl1_hstx_data_i<6> dl1_hstx_data_o<6> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI172<5> net0132 dl1_hstx_data_i<5> dl1_hstx_data_o<5> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI172<4> net0132 dl1_hstx_data_i<4> dl1_hstx_data_o<4> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI172<3> net0132 dl1_hstx_data_i<3> dl1_hstx_data_o<3> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI172<2> net0132 dl1_hstx_data_i<2> dl1_hstx_data_o<2> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI172<1> net0132 dl1_hstx_data_i<1> dl1_hstx_data_o<1> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI172<0> net0132 dl1_hstx_data_i<0> dl1_hstx_data_o<0> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2Q
  XI186 net0206 net0200 inh_bulk_n inh_bulk_p VDD VSS BUF24
  XI165 net0206 net0263 inh_bulk_n inh_bulk_p VDD VSS BUF24
  XI204 net0206 dphy_reset_n_o inh_bulk_n inh_bulk_p VDD VSS BUF4
  XI178<15> net0240 dl3_dft_hstx_data_lpbk_i<15> net0235<15> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI178<14> net0240 dl3_dft_hstx_data_lpbk_i<14> net0235<14> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI178<13> net0240 dl3_dft_hstx_data_lpbk_i<13> net0235<13> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI178<12> net0240 dl3_dft_hstx_data_lpbk_i<12> net0235<12> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI178<11> net0240 dl3_dft_hstx_data_lpbk_i<11> net0235<11> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI178<10> net0240 dl3_dft_hstx_data_lpbk_i<10> net0235<10> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI178<9> net0240 dl3_dft_hstx_data_lpbk_i<9> net0235<9> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI178<8> net0240 dl3_dft_hstx_data_lpbk_i<8> net0235<8> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI178<7> net0240 dl3_dft_hstx_data_lpbk_i<7> net0235<7> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI178<6> net0240 dl3_dft_hstx_data_lpbk_i<6> net0235<6> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI178<5> net0240 dl3_dft_hstx_data_lpbk_i<5> net0235<5> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI178<4> net0240 dl3_dft_hstx_data_lpbk_i<4> net0235<4> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI178<3> net0240 dl3_dft_hstx_data_lpbk_i<3> net0235<3> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI178<2> net0240 dl3_dft_hstx_data_lpbk_i<2> net0235<2> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI178<1> net0240 dl3_dft_hstx_data_lpbk_i<1> net0235<1> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI178<0> net0240 dl3_dft_hstx_data_lpbk_i<0> net0235<0> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI176<15> net0204 dl2_dft_hstx_data_lpbk_i<15> net0407<15> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI176<14> net0204 dl2_dft_hstx_data_lpbk_i<14> net0407<14> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI176<13> net0204 dl2_dft_hstx_data_lpbk_i<13> net0407<13> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI176<12> net0204 dl2_dft_hstx_data_lpbk_i<12> net0407<12> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI176<11> net0204 dl2_dft_hstx_data_lpbk_i<11> net0407<11> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI176<10> net0204 dl2_dft_hstx_data_lpbk_i<10> net0407<10> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI176<9> net0204 dl2_dft_hstx_data_lpbk_i<9> net0407<9> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI176<8> net0204 dl2_dft_hstx_data_lpbk_i<8> net0407<8> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI176<7> net0204 dl2_dft_hstx_data_lpbk_i<7> net0407<7> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI176<6> net0204 dl2_dft_hstx_data_lpbk_i<6> net0407<6> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI176<5> net0204 dl2_dft_hstx_data_lpbk_i<5> net0407<5> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI176<4> net0204 dl2_dft_hstx_data_lpbk_i<4> net0407<4> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI176<3> net0204 dl2_dft_hstx_data_lpbk_i<3> net0407<3> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI176<2> net0204 dl2_dft_hstx_data_lpbk_i<2> net0407<2> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI176<1> net0204 dl2_dft_hstx_data_lpbk_i<1> net0407<1> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI176<0> net0204 dl2_dft_hstx_data_lpbk_i<0> net0407<0> net0200 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI174<15> net0168 cl_dft_hstx_data_lpbk_i<15> net0351<15> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI174<14> net0168 cl_dft_hstx_data_lpbk_i<14> net0351<14> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI174<13> net0168 cl_dft_hstx_data_lpbk_i<13> net0351<13> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI174<12> net0168 cl_dft_hstx_data_lpbk_i<12> net0351<12> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI174<11> net0168 cl_dft_hstx_data_lpbk_i<11> net0351<11> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI174<10> net0168 cl_dft_hstx_data_lpbk_i<10> net0351<10> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI174<9> net0168 cl_dft_hstx_data_lpbk_i<9> net0351<9> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI174<8> net0168 cl_dft_hstx_data_lpbk_i<8> net0351<8> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI174<7> net0168 cl_dft_hstx_data_lpbk_i<7> net0351<7> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI174<6> net0168 cl_dft_hstx_data_lpbk_i<6> net0351<6> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI174<5> net0168 cl_dft_hstx_data_lpbk_i<5> net0351<5> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI174<4> net0168 cl_dft_hstx_data_lpbk_i<4> net0351<4> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI174<3> net0168 cl_dft_hstx_data_lpbk_i<3> net0351<3> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI174<2> net0168 cl_dft_hstx_data_lpbk_i<2> net0351<2> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI174<1> net0168 cl_dft_hstx_data_lpbk_i<1> net0351<1> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI174<0> net0168 cl_dft_hstx_data_lpbk_i<0> net0351<0> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI171<15> net0132 dl1_dft_hstx_data_lpbk_i<15> dl1_dft_hstx_data_lpbk_o<15> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI171<14> net0132 dl1_dft_hstx_data_lpbk_i<14> dl1_dft_hstx_data_lpbk_o<14> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI171<13> net0132 dl1_dft_hstx_data_lpbk_i<13> dl1_dft_hstx_data_lpbk_o<13> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI171<12> net0132 dl1_dft_hstx_data_lpbk_i<12> dl1_dft_hstx_data_lpbk_o<12> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI171<11> net0132 dl1_dft_hstx_data_lpbk_i<11> dl1_dft_hstx_data_lpbk_o<11> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI171<10> net0132 dl1_dft_hstx_data_lpbk_i<10> dl1_dft_hstx_data_lpbk_o<10> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI171<9> net0132 dl1_dft_hstx_data_lpbk_i<9> dl1_dft_hstx_data_lpbk_o<9> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI171<8> net0132 dl1_dft_hstx_data_lpbk_i<8> dl1_dft_hstx_data_lpbk_o<8> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI171<7> net0132 dl1_dft_hstx_data_lpbk_i<7> dl1_dft_hstx_data_lpbk_o<7> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI171<6> net0132 dl1_dft_hstx_data_lpbk_i<6> dl1_dft_hstx_data_lpbk_o<6> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI171<5> net0132 dl1_dft_hstx_data_lpbk_i<5> dl1_dft_hstx_data_lpbk_o<5> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI171<4> net0132 dl1_dft_hstx_data_lpbk_i<4> dl1_dft_hstx_data_lpbk_o<4> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI171<3> net0132 dl1_dft_hstx_data_lpbk_i<3> dl1_dft_hstx_data_lpbk_o<3> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI171<2> net0132 dl1_dft_hstx_data_lpbk_i<2> dl1_dft_hstx_data_lpbk_o<2> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI171<1> net0132 dl1_dft_hstx_data_lpbk_i<1> dl1_dft_hstx_data_lpbk_o<1> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI171<0> net0132 dl1_dft_hstx_data_lpbk_i<0> dl1_dft_hstx_data_lpbk_o<0> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI73<15> net099 dl0_dft_hstx_data_lpbk_i<15> dl0_dft_hstx_data_lpbk_o<15> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI73<14> net099 dl0_dft_hstx_data_lpbk_i<14> dl0_dft_hstx_data_lpbk_o<14> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI73<13> net099 dl0_dft_hstx_data_lpbk_i<13> dl0_dft_hstx_data_lpbk_o<13> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI73<12> net099 dl0_dft_hstx_data_lpbk_i<12> dl0_dft_hstx_data_lpbk_o<12> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI73<11> net099 dl0_dft_hstx_data_lpbk_i<11> dl0_dft_hstx_data_lpbk_o<11> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI73<10> net099 dl0_dft_hstx_data_lpbk_i<10> dl0_dft_hstx_data_lpbk_o<10> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI73<9> net099 dl0_dft_hstx_data_lpbk_i<9> dl0_dft_hstx_data_lpbk_o<9> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI73<8> net099 dl0_dft_hstx_data_lpbk_i<8> dl0_dft_hstx_data_lpbk_o<8> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI73<7> net099 dl0_dft_hstx_data_lpbk_i<7> dl0_dft_hstx_data_lpbk_o<7> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI73<6> net099 dl0_dft_hstx_data_lpbk_i<6> dl0_dft_hstx_data_lpbk_o<6> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI73<5> net099 dl0_dft_hstx_data_lpbk_i<5> dl0_dft_hstx_data_lpbk_o<5> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI73<4> net099 dl0_dft_hstx_data_lpbk_i<4> dl0_dft_hstx_data_lpbk_o<4> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI73<3> net099 dl0_dft_hstx_data_lpbk_i<3> dl0_dft_hstx_data_lpbk_o<3> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI73<2> net099 dl0_dft_hstx_data_lpbk_i<2> dl0_dft_hstx_data_lpbk_o<2> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI73<1> net099 dl0_dft_hstx_data_lpbk_i<1> dl0_dft_hstx_data_lpbk_o<1> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI73<0> net099 dl0_dft_hstx_data_lpbk_i<0> dl0_dft_hstx_data_lpbk_o<0> net0263 inh_bulk_n inh_bulk_p VDD VSS FD2QV
  XI82 dl1_dft_hstx_lower_path_en_i dl1_hstx_en_lptx_dis_i dl1_en_s dl1_dft_hstx_lower_path_en_o inh_bulk_n inh_bulk_p VDD VSS AND3B
  XI81 dl1_dft_hstx_higher_path_en_i dl1_hstx_en_lptx_dis_i dl1_en_s dl1_hstx_en_lptx_dis_o inh_bulk_n inh_bulk_p VDD VSS AND3B
  XI75 dl0_dft_hstx_higher_path_en_i dl0_hstx_en_lptx_dis_i dl0_en_s dl0_hstx_en_lptx_dis_o inh_bulk_n inh_bulk_p VDD VSS AND3B
  XI74 dl0_dft_hstx_lower_path_en_i dl0_hstx_en_lptx_dis_i dl0_en_s dl0_dft_hstx_lower_path_en_o inh_bulk_n inh_bulk_p VDD VSS AND3B
  XI136 net0227 net0210 dl3_en_s dl3_dft_hstx_lower_path_en_o inh_bulk_n inh_bulk_p VDD VSS AND3B
  XI97 net0219 net0384 cl_en_s cl_hstx_en_lptx_dis_o inh_bulk_n inh_bulk_p VDD VSS AND3B
  XI98 net0376 net0384 cl_en_s cl_dft_hstx_lower_path_en_o inh_bulk_n inh_bulk_p VDD VSS AND3B
  XI117 net0359 net0207 dl2_en_s dl2_dft_hstx_lower_path_en_o inh_bulk_n inh_bulk_p VDD VSS AND3B
  XI116 net0357 net0207 dl2_en_s dl2_hstx_en_lptx_dis_o inh_bulk_n inh_bulk_p VDD VSS AND3B
  XI135 net0217 net0210 dl3_en_s dl3_hstx_en_lptx_dis_o inh_bulk_n inh_bulk_p VDD VSS AND3B
  XI155 dl0_en_s dl0_hstx_pwrdn_i dl0_hstx_pwrdn_o inh_bulk_n inh_bulk_p VDD VSS OR2I
  XI156 dl1_en_s dl1_hstx_pwrdn_i dl1_hstx_pwrdn_o inh_bulk_n inh_bulk_p VDD VSS OR2I
  XI157 cl_en_s net0424 cl_hstx_pwrdn_o inh_bulk_n inh_bulk_p VDD VSS OR2I
  XI158 dl2_en_s net0340 dl2_hstx_pwrdn_o inh_bulk_n inh_bulk_p VDD VSS OR2I
  XI159 dl3_en_s net0231 dl3_hstx_pwrdn_o inh_bulk_n inh_bulk_p VDD VSS OR2I
  XI184 clk_byte_i en_clk_byte_s clk_byte_s inh_bulk_n inh_bulk_p VDD VSS AND2V
  XI205 net0444 net0188 net0206 inh_bulk_n inh_bulk_p VDD VSS AND2V
  XI152 clk_byte_s net0240 inh_bulk_n inh_bulk_p VDD VSS BUF12
  XI133 clk_byte_s net0204 inh_bulk_n inh_bulk_p VDD VSS BUF12
  XI114 clk_byte_s net0168 inh_bulk_n inh_bulk_p VDD VSS BUF12
  XI79 clk_byte_s net0132 inh_bulk_n inh_bulk_p VDD VSS BUF12
  XI77 clk_byte_s net099 inh_bulk_n inh_bulk_p VDD VSS BUF12
  XI34 pwd_s dphy_pwrdn_o inh_bulk_n inh_bulk_p VDD VSS BUF2
  XI216 clk_byte_i net0218 inh_bulk_n inh_bulk_p VDD VSS INV2
  XI552 net0401 net0464 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI551 net0434 net0401 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI550 net0450 net0447 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI549 net0447 net0444 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI548 net0395 net0450 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI547 dphy_reset_n_i net0395 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI546<15> net0364<15> net0463<15> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI546<14> net0364<14> net0463<14> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI546<13> net0364<13> net0463<13> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI546<12> net0364<12> net0463<12> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI546<11> net0364<11> net0463<11> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI546<10> net0364<10> net0463<10> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI546<9> net0364<9> net0463<9> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI546<8> net0364<8> net0463<8> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI546<7> net0364<7> net0463<7> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI546<6> net0364<6> net0463<6> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI546<5> net0364<5> net0463<5> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI546<4> net0364<4> net0463<4> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI546<3> net0364<3> net0463<3> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI546<2> net0364<2> net0463<2> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI546<1> net0364<1> net0463<1> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI546<0> net0364<0> net0463<0> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI545<15> cl_hstx_data_i<15> net0364<15> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI545<14> cl_hstx_data_i<14> net0364<14> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI545<13> cl_hstx_data_i<13> net0364<13> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI545<12> cl_hstx_data_i<12> net0364<12> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI545<11> cl_hstx_data_i<11> net0364<11> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI545<10> cl_hstx_data_i<10> net0364<10> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI545<9> cl_hstx_data_i<9> net0364<9> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI545<8> cl_hstx_data_i<8> net0364<8> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI545<7> cl_hstx_data_i<7> net0364<7> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI545<6> cl_hstx_data_i<6> net0364<6> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI545<5> cl_hstx_data_i<5> net0364<5> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI545<4> cl_hstx_data_i<4> net0364<4> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI545<3> cl_hstx_data_i<3> net0364<3> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI545<2> cl_hstx_data_i<2> net0364<2> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI545<1> cl_hstx_data_i<1> net0364<1> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI545<0> cl_hstx_data_i<0> net0364<0> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI544<15> net0366<15> net0369<15> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI544<14> net0366<14> net0369<14> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI544<13> net0366<13> net0369<13> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI544<12> net0366<12> net0369<12> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI544<11> net0366<11> net0369<11> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI544<10> net0366<10> net0369<10> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI544<9> net0366<9> net0369<9> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI544<8> net0366<8> net0369<8> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI544<7> net0366<7> net0369<7> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI544<6> net0366<6> net0369<6> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI544<5> net0366<5> net0369<5> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI544<4> net0366<4> net0369<4> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI544<3> net0366<3> net0369<3> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI544<2> net0366<2> net0369<2> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI544<1> net0366<1> net0369<1> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI544<0> net0366<0> net0369<0> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI543<15> dl2_hstx_data_i<15> net0366<15> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI543<14> dl2_hstx_data_i<14> net0366<14> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI543<13> dl2_hstx_data_i<13> net0366<13> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI543<12> dl2_hstx_data_i<12> net0366<12> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI543<11> dl2_hstx_data_i<11> net0366<11> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI543<10> dl2_hstx_data_i<10> net0366<10> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI543<9> dl2_hstx_data_i<9> net0366<9> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI543<8> dl2_hstx_data_i<8> net0366<8> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI543<7> dl2_hstx_data_i<7> net0366<7> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI543<6> dl2_hstx_data_i<6> net0366<6> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI543<5> dl2_hstx_data_i<5> net0366<5> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI543<4> dl2_hstx_data_i<4> net0366<4> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI543<3> dl2_hstx_data_i<3> net0366<3> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI543<2> dl2_hstx_data_i<2> net0366<2> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI543<1> dl2_hstx_data_i<1> net0366<1> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI543<0> dl2_hstx_data_i<0> net0366<0> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI542<15> dl3_hstx_data_i<15> net0400<15> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI542<14> dl3_hstx_data_i<14> net0400<14> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI542<13> dl3_hstx_data_i<13> net0400<13> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI542<12> dl3_hstx_data_i<12> net0400<12> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI542<11> dl3_hstx_data_i<11> net0400<11> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI542<10> dl3_hstx_data_i<10> net0400<10> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI542<9> dl3_hstx_data_i<9> net0400<9> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI542<8> dl3_hstx_data_i<8> net0400<8> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI542<7> dl3_hstx_data_i<7> net0400<7> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI542<6> dl3_hstx_data_i<6> net0400<6> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI542<5> dl3_hstx_data_i<5> net0400<5> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI542<4> dl3_hstx_data_i<4> net0400<4> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI542<3> dl3_hstx_data_i<3> net0400<3> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI542<2> dl3_hstx_data_i<2> net0400<2> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI542<1> dl3_hstx_data_i<1> net0400<1> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI542<0> dl3_hstx_data_i<0> net0400<0> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI416<15> net0421<15> dl2_dft_hstx_data_lpbk_o<15> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI416<14> net0421<14> dl2_dft_hstx_data_lpbk_o<14> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI416<13> net0421<13> dl2_dft_hstx_data_lpbk_o<13> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI416<12> net0421<12> dl2_dft_hstx_data_lpbk_o<12> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI416<11> net0421<11> dl2_dft_hstx_data_lpbk_o<11> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI416<10> net0421<10> dl2_dft_hstx_data_lpbk_o<10> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI416<9> net0421<9> dl2_dft_hstx_data_lpbk_o<9> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI416<8> net0421<8> dl2_dft_hstx_data_lpbk_o<8> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI416<7> net0421<7> dl2_dft_hstx_data_lpbk_o<7> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI416<6> net0421<6> dl2_dft_hstx_data_lpbk_o<6> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI416<5> net0421<5> dl2_dft_hstx_data_lpbk_o<5> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI416<4> net0421<4> dl2_dft_hstx_data_lpbk_o<4> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI416<3> net0421<3> dl2_dft_hstx_data_lpbk_o<3> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI416<2> net0421<2> dl2_dft_hstx_data_lpbk_o<2> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI416<1> net0421<1> dl2_dft_hstx_data_lpbk_o<1> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI416<0> net0421<0> dl2_dft_hstx_data_lpbk_o<0> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI415<15> net0407<15> net0421<15> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI415<14> net0407<14> net0421<14> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI415<13> net0407<13> net0421<13> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI415<12> net0407<12> net0421<12> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI415<11> net0407<11> net0421<11> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI415<10> net0407<10> net0421<10> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI415<9> net0407<9> net0421<9> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI415<8> net0407<8> net0421<8> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI415<7> net0407<7> net0421<7> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI415<6> net0407<6> net0421<6> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI415<5> net0407<5> net0421<5> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI415<4> net0407<4> net0421<4> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI415<3> net0407<3> net0421<3> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI415<2> net0407<2> net0421<2> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI415<1> net0407<1> net0421<1> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI415<0> net0407<0> net0421<0> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI539<15> net0437<15> net0385<15> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI539<14> net0437<14> net0385<14> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI539<13> net0437<13> net0385<13> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI539<12> net0437<12> net0385<12> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI539<11> net0437<11> net0385<11> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI539<10> net0437<10> net0385<10> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI539<9> net0437<9> net0385<9> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI539<8> net0437<8> net0385<8> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI539<7> net0437<7> net0385<7> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI539<6> net0437<6> net0385<6> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI539<5> net0437<5> net0385<5> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI539<4> net0437<4> net0385<4> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI539<3> net0437<3> net0385<3> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI539<2> net0437<2> net0385<2> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI539<1> net0437<1> net0385<1> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI539<0> net0437<0> net0385<0> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI407 en_clk_dphy_i net0441 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI408 sel_dr_i net0379 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI409 hstx_en_fast_trf_i net0435 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI410 net0441 net0434 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI411 net0435 net0448 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI412 net0379 net0428 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI505 cl_dft_hstx_higher_path_en_i net0483 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI521 net0418 net0397 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI522 cl_hs_ser_en_i net0472 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI506 cl_hstx_pwrdn_i net0479 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI392<15> net0402<15> cl_dft_hstx_data_lpbk_o<15> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI392<14> net0402<14> cl_dft_hstx_data_lpbk_o<14> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI392<13> net0402<13> cl_dft_hstx_data_lpbk_o<13> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI392<12> net0402<12> cl_dft_hstx_data_lpbk_o<12> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI392<11> net0402<11> cl_dft_hstx_data_lpbk_o<11> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI392<10> net0402<10> cl_dft_hstx_data_lpbk_o<10> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI392<9> net0402<9> cl_dft_hstx_data_lpbk_o<9> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI392<8> net0402<8> cl_dft_hstx_data_lpbk_o<8> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI392<7> net0402<7> cl_dft_hstx_data_lpbk_o<7> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI392<6> net0402<6> cl_dft_hstx_data_lpbk_o<6> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI392<5> net0402<5> cl_dft_hstx_data_lpbk_o<5> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI392<4> net0402<4> cl_dft_hstx_data_lpbk_o<4> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI392<3> net0402<3> cl_dft_hstx_data_lpbk_o<3> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI392<2> net0402<2> cl_dft_hstx_data_lpbk_o<2> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI392<1> net0402<1> cl_dft_hstx_data_lpbk_o<1> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI392<0> net0402<0> cl_dft_hstx_data_lpbk_o<0> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI414<15> net0351<15> net0402<15> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI414<14> net0351<14> net0402<14> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI414<13> net0351<13> net0402<13> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI414<12> net0351<12> net0402<12> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI414<11> net0351<11> net0402<11> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI414<10> net0351<10> net0402<10> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI414<9> net0351<9> net0402<9> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI414<8> net0351<8> net0402<8> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI414<7> net0351<7> net0402<7> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI414<6> net0351<6> net0402<6> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI414<5> net0351<5> net0402<5> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI414<4> net0351<4> net0402<4> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI414<3> net0351<3> net0402<3> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI414<2> net0351<2> net0402<2> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI414<1> net0351<1> net0402<1> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI414<0> net0351<0> net0402<0> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI536 hs_ser_msb_first_en_i net0382 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI535 dft_dphy_ocdldo_res_dis_i net0431 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI534 net0431 net0396 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI533 net0382 net0371 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI532<2> cl_delay_prog_i<2> net0461<2> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI532<1> cl_delay_prog_i<1> net0461<1> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI532<0> cl_delay_prog_i<0> net0461<0> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI531 net0482 net0420 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI530 cl_dft_deser_en_i net0482 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI529 cl_dft_ser_test_in_en_i net0480 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI528 net0480 net0386 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI527 net0475 net0389 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI526 cl_dft_ser_test_n_i net0475 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI525 cl_dft_ser_test_p_i net0484 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI524 net0484 net0423 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI523 net0472 net0411 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI520 cl_bypass_delay_line_i net0418 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI519 cl_lptx_en_i net0409 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI518 net0409 net0416 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI517 net0481 net0417 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI516 cl_lptx_dp_i net0481 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI515 cl_lptx_dn_i net0414 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI514 net0414 net0399 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI513<2> net0461<2> net0352<2> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI513<1> net0461<1> net0352<1> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI513<0> net0461<0> net0352<0> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI512 net0483 net0219 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI511 net0419 net0384 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI510 cl_hstx_en_lptx_dis_i net0419 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI509 cl_dft_hstx_lower_path_en_i net0457 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI508 net0457 net0376 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI507 net0479 net0424 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI434 dl3_hstx_pwrdn_i net0426 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI476 net0225 net0224 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI475 net0226 net0225 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI474 dl3_dft_deser_en_i net0226 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI473 net0224 net0270 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI472 net0229 net0266 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI433 net0430 net0231 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI471 dl3_dft_ser_test_in_en_i net0404 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI432 net0255 net0227 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI470 net0404 net0436 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI469 net0436 net0229 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI468 net0440 net0230 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI467 net0398 net0440 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI466 dl3_dft_ser_test_n_i net0398 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI431 dl3_dft_hstx_lower_path_en_i net0308 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI465 net0230 net0298 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI430 net0308 net0306 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI464 net0381 net0259 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI463 dl3_dft_ser_test_p_i net0406 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI462 net0406 net0405 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI461 net0405 net0381 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI460 net0237 net0236 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI429 net0306 net0255 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI459 net0238 net0237 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI428 net0305 net0261 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI458 dl3_hs_ser_en_i net0238 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI457 net0236 net0254 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI456 net0241 net0251 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI455 dl3_lptx_dn_i net0239 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI454 net0239 net0443 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI427 net0257 net0305 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI453 net0443 net0241 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI426 dl3_hstx_en_lptx_dis_i net0257 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI452 net0422 net0393 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI451 net0244 net0422 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI450 dl3_lptx_dp_i net0244 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI449 net0393 net0248 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI448 net0247 net0243 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI447 dl3_lptx_en_i net0245 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI446 net0245 net0246 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI425 net0261 net0210 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI424 net0260 net0217 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI423 net0258 net0260 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI421 dl3_dft_hstx_higher_path_en_i net0256 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI445 net0246 net0247 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI444 net0249 net0442 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI443 net0250 net0249 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI442 dl3_bypass_delay_line_i net0250 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI441 net0442 net0242 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI437<2> net0372<2> net0390<2> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI437<1> net0372<1> net0390<1> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI437<0> net0372<0> net0390<0> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI440<2> net0390<2> net0294<2> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI440<1> net0390<1> net0294<1> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI440<0> net0390<0> net0294<0> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI422 net0256 net0258 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI438<2> net0370<2> net0372<2> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI438<1> net0370<1> net0372<1> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI438<0> net0370<0> net0372<0> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI436 net0432 net0430 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI435 net0426 net0432 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI439<2> dl3_delay_prog_i<2> net0370<2> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI439<1> dl3_delay_prog_i<1> net0370<1> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI439<0> dl3_delay_prog_i<0> net0370<0> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI496 dl2_hs_ser_en_i net0451 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI491 net0460 net0349 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI480 dl2_hstx_en_lptx_dis_i net0415 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI490 net0438 net0360 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI504 net0453 net0326 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI503 dl2_lptx_dn_i net0453 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI417<15> net0233<15> net0232<15> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI417<14> net0233<14> net0232<14> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI417<13> net0233<13> net0232<13> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI417<12> net0233<12> net0232<12> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI417<11> net0233<11> net0232<11> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI417<10> net0233<10> net0232<10> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI417<9> net0233<9> net0232<9> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI417<8> net0233<8> net0232<8> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI417<7> net0233<7> net0232<7> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI417<6> net0233<6> net0232<6> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI417<5> net0233<5> net0232<5> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI417<4> net0233<4> net0232<4> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI417<3> net0233<3> net0232<3> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI417<2> net0233<2> net0232<2> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI417<1> net0233<1> net0232<1> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI417<0> net0233<0> net0232<0> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI487 net0452 net0343 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI485<2> net0365<2> net0313<2> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI485<1> net0365<1> net0313<1> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI485<0> net0365<0> net0313<0> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI497 net0456 net0344 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI492 dl2_dft_ser_test_n_i net0460 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI493 dl2_dft_ser_test_p_i net0467 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI494 net0467 net0328 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI495 net0451 net0356 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI418<15> net0232<15> dl3_dft_hstx_data_lpbk_o<15> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI418<14> net0232<14> dl3_dft_hstx_data_lpbk_o<14> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI418<13> net0232<13> dl3_dft_hstx_data_lpbk_o<13> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI418<12> net0232<12> dl3_dft_hstx_data_lpbk_o<12> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI418<11> net0232<11> dl3_dft_hstx_data_lpbk_o<11> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI418<10> net0232<10> dl3_dft_hstx_data_lpbk_o<10> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI418<9> net0232<9> dl3_dft_hstx_data_lpbk_o<9> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI418<8> net0232<8> dl3_dft_hstx_data_lpbk_o<8> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI418<7> net0232<7> dl3_dft_hstx_data_lpbk_o<7> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI418<6> net0232<6> dl3_dft_hstx_data_lpbk_o<6> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI418<5> net0232<5> dl3_dft_hstx_data_lpbk_o<5> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI418<4> net0232<4> dl3_dft_hstx_data_lpbk_o<4> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI418<3> net0232<3> dl3_dft_hstx_data_lpbk_o<3> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI418<2> net0232<2> dl3_dft_hstx_data_lpbk_o<2> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI418<1> net0232<1> dl3_dft_hstx_data_lpbk_o<1> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI418<0> net0232<0> dl3_dft_hstx_data_lpbk_o<0> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI477 dl2_dft_hstx_higher_path_en_i net0454 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI488 dl2_dft_deser_en_i net0452 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI498 dl2_bypass_delay_line_i net0456 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI478 net0454 net0357 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI486<2> dl2_delay_prog_i<2> net0365<2> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI486<1> dl2_delay_prog_i<1> net0365<1> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI486<0> dl2_delay_prog_i<0> net0365<0> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI500 net0469 net0228 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI499 dl2_lptx_en_i net0469 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI502 dl2_lptx_dp_i net0429 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI501 net0429 net0345 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI489 dl2_dft_ser_test_in_en_i net0438 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI479 net0415 net0207 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI540<15> net0439<15> net0437<15> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI540<14> net0439<14> net0437<14> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI540<13> net0439<13> net0437<13> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI540<12> net0439<12> net0437<12> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI540<11> net0439<11> net0437<11> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI540<10> net0439<10> net0437<10> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI540<9> net0439<9> net0437<9> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI540<8> net0439<8> net0437<8> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI540<7> net0439<7> net0437<7> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI540<6> net0439<6> net0437<6> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI540<5> net0439<5> net0437<5> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI540<4> net0439<4> net0437<4> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI540<3> net0439<3> net0437<3> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI540<2> net0439<2> net0437<2> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI540<1> net0439<1> net0437<1> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI540<0> net0439<0> net0437<0> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI420<15> net0235<15> net0234<15> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI420<14> net0235<14> net0234<14> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI420<13> net0235<13> net0234<13> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI420<12> net0235<12> net0234<12> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI420<11> net0235<11> net0234<11> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI420<10> net0235<10> net0234<10> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI420<9> net0235<9> net0234<9> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI420<8> net0235<8> net0234<8> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI420<7> net0235<7> net0234<7> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI420<6> net0235<6> net0234<6> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI420<5> net0235<5> net0234<5> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI420<4> net0235<4> net0234<4> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI420<3> net0235<3> net0234<3> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI420<2> net0235<2> net0234<2> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI420<1> net0235<1> net0234<1> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI420<0> net0235<0> net0234<0> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI419<15> net0234<15> net0233<15> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI419<14> net0234<14> net0233<14> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI419<13> net0234<13> net0233<13> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI419<12> net0234<12> net0233<12> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI419<11> net0234<11> net0233<11> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI419<10> net0234<10> net0233<10> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI419<9> net0234<9> net0233<9> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI419<8> net0234<8> net0233<8> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI419<7> net0234<7> net0233<7> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI419<6> net0234<6> net0233<6> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI419<5> net0234<5> net0233<5> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI419<4> net0234<4> net0233<4> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI419<3> net0234<3> net0233<3> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI419<2> net0234<2> net0233<2> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI419<1> net0234<1> net0233<1> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI419<0> net0234<0> net0233<0> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI483 net0466 net0340 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI481 dl2_dft_hstx_lower_path_en_i net0449 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI482 net0449 net0359 inh_bulk_n inh_bulk_p VDD VSS INV8
  XI541<15> net0400<15> net0439<15> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI541<14> net0400<14> net0439<14> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI541<13> net0400<13> net0439<13> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI541<12> net0400<12> net0439<12> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI541<11> net0400<11> net0439<11> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI541<10> net0400<10> net0439<10> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI541<9> net0400<9> net0439<9> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI541<8> net0400<8> net0439<8> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI541<7> net0400<7> net0439<7> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI541<6> net0400<6> net0439<6> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI541<5> net0400<5> net0439<5> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI541<4> net0400<4> net0439<4> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI541<3> net0400<3> net0439<3> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI541<2> net0400<2> net0439<2> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI541<1> net0400<1> net0439<1> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI541<0> net0400<0> net0439<0> inh_bulk_n inh_bulk_p VDD VSS INV8
  XI484 dl2_hstx_pwrdn_i net0466 inh_bulk_n inh_bulk_p VDD VSS INV8
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: phy_ana_top
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT phy_ana_top GNDA GNDD VDDA1V5 VDDD1V5 ck50m4iq_n_i ck50m4iq_p_i cl_bypass_delay_line_i cl_delay_prog_i<2> cl_delay_prog_i<1> cl_delay_prog_i<0> cl_dft_deser_en_i cl_dft_hstx_data_lpbk_o<15> cl_dft_hstx_data_lpbk_o<14> cl_dft_hstx_data_lpbk_o<13>
+ cl_dft_hstx_data_lpbk_o<12> cl_dft_hstx_data_lpbk_o<11> cl_dft_hstx_data_lpbk_o<10> cl_dft_hstx_data_lpbk_o<9> cl_dft_hstx_data_lpbk_o<8> cl_dft_hstx_data_lpbk_o<7> cl_dft_hstx_data_lpbk_o<6> cl_dft_hstx_data_lpbk_o<5> cl_dft_hstx_data_lpbk_o<4>
+ cl_dft_hstx_data_lpbk_o<3> cl_dft_hstx_data_lpbk_o<2> cl_dft_hstx_data_lpbk_o<1> cl_dft_hstx_data_lpbk_o<0> cl_dft_hstx_higher_path_en_i cl_dft_hstx_lower_path_en_i cl_dft_ser_test_in_en_i cl_dft_ser_test_n_i cl_dft_ser_test_p_i cl_hs_ser_en_i
+ cl_hstx_data_i<15> cl_hstx_data_i<14> cl_hstx_data_i<13> cl_hstx_data_i<12> cl_hstx_data_i<11> cl_hstx_data_i<10> cl_hstx_data_i<9> cl_hstx_data_i<8> cl_hstx_data_i<7> cl_hstx_data_i<6> cl_hstx_data_i<5> cl_hstx_data_i<4> cl_hstx_data_i<3> cl_hstx_data_i<2>
+ cl_hstx_data_i<1> cl_hstx_data_i<0> cl_hstx_en_lptx_dis_i cl_hstx_pwrdn_i cl_lptx_dn_i cl_lptx_dp_i cl_lptx_en_i clk_byte_o clk_dphy_0_i clk_dphy_90_i clk_dphy_180_i clk_dphy_270_i dft_ana_test_ao dft_ana_test_en_i dft_ana_test_out_dphy_sel_i<3>
+ dft_ana_test_out_dphy_sel_i<2> dft_ana_test_out_dphy_sel_i<1> dft_ana_test_out_dphy_sel_i<0> dft_dphy_ocdldo_res_dis_i dft_pll_clks_2_cl_en_i dft_scan_mode_i div_clk_dphy_i dl0_bypass_delay_line_i dl0_delay_prog_i<2> dl0_delay_prog_i<1> dl0_delay_prog_i<0>
+ dl0_dft_deser_en_i dl0_dft_hstx_data_lpbk_o<15> dl0_dft_hstx_data_lpbk_o<14> dl0_dft_hstx_data_lpbk_o<13> dl0_dft_hstx_data_lpbk_o<12> dl0_dft_hstx_data_lpbk_o<11> dl0_dft_hstx_data_lpbk_o<10> dl0_dft_hstx_data_lpbk_o<9> dl0_dft_hstx_data_lpbk_o<8>
+ dl0_dft_hstx_data_lpbk_o<7> dl0_dft_hstx_data_lpbk_o<6> dl0_dft_hstx_data_lpbk_o<5> dl0_dft_hstx_data_lpbk_o<4> dl0_dft_hstx_data_lpbk_o<3> dl0_dft_hstx_data_lpbk_o<2> dl0_dft_hstx_data_lpbk_o<1> dl0_dft_hstx_data_lpbk_o<0> dl0_dft_hstx_higher_path_en_i
+ dl0_dft_hstx_lower_path_en_i dl0_dft_ser_test_in_en_i dl0_dft_ser_test_n_i dl0_dft_ser_test_p_i dl0_hs_ser_en_i dl0_hstx_data_i<15> dl0_hstx_data_i<14> dl0_hstx_data_i<13> dl0_hstx_data_i<12> dl0_hstx_data_i<11> dl0_hstx_data_i<10> dl0_hstx_data_i<9>
+ dl0_hstx_data_i<8> dl0_hstx_data_i<7> dl0_hstx_data_i<6> dl0_hstx_data_i<5> dl0_hstx_data_i<4> dl0_hstx_data_i<3> dl0_hstx_data_i<2> dl0_hstx_data_i<1> dl0_hstx_data_i<0> dl0_hstx_en_lptx_dis_i dl0_hstx_pwrdn_i dl0_lptx_dn_i dl0_lptx_dp_i dl0_lptx_en_i
+ dl1_bypass_delay_line_i dl1_delay_prog_i<2> dl1_delay_prog_i<1> dl1_delay_prog_i<0> dl1_dft_deser_en_i dl1_dft_hstx_data_lpbk_o<15> dl1_dft_hstx_data_lpbk_o<14> dl1_dft_hstx_data_lpbk_o<13> dl1_dft_hstx_data_lpbk_o<12> dl1_dft_hstx_data_lpbk_o<11>
+ dl1_dft_hstx_data_lpbk_o<10> dl1_dft_hstx_data_lpbk_o<9> dl1_dft_hstx_data_lpbk_o<8> dl1_dft_hstx_data_lpbk_o<7> dl1_dft_hstx_data_lpbk_o<6> dl1_dft_hstx_data_lpbk_o<5> dl1_dft_hstx_data_lpbk_o<4> dl1_dft_hstx_data_lpbk_o<3> dl1_dft_hstx_data_lpbk_o<2>
+ dl1_dft_hstx_data_lpbk_o<1> dl1_dft_hstx_data_lpbk_o<0> dl1_dft_hstx_higher_path_en_i dl1_dft_hstx_lower_path_en_i dl1_dft_ser_test_in_en_i dl1_dft_ser_test_n_i dl1_dft_ser_test_p_i dl1_hs_ser_en_i dl1_hstx_data_i<15> dl1_hstx_data_i<14> dl1_hstx_data_i<13>
+ dl1_hstx_data_i<12> dl1_hstx_data_i<11> dl1_hstx_data_i<10> dl1_hstx_data_i<9> dl1_hstx_data_i<8> dl1_hstx_data_i<7> dl1_hstx_data_i<6> dl1_hstx_data_i<5> dl1_hstx_data_i<4> dl1_hstx_data_i<3> dl1_hstx_data_i<2> dl1_hstx_data_i<1> dl1_hstx_data_i<0>
+ dl1_hstx_en_lptx_dis_i dl1_hstx_pwrdn_i dl1_lptx_dn_i dl1_lptx_dp_i dl1_lptx_en_i dl2_bypass_delay_line_i dl2_delay_prog_i<2> dl2_delay_prog_i<1> dl2_delay_prog_i<0> dl2_dft_deser_en_i dl2_dft_hstx_data_lpbk_o<15> dl2_dft_hstx_data_lpbk_o<14>
+ dl2_dft_hstx_data_lpbk_o<13> dl2_dft_hstx_data_lpbk_o<12> dl2_dft_hstx_data_lpbk_o<11> dl2_dft_hstx_data_lpbk_o<10> dl2_dft_hstx_data_lpbk_o<9> dl2_dft_hstx_data_lpbk_o<8> dl2_dft_hstx_data_lpbk_o<7> dl2_dft_hstx_data_lpbk_o<6> dl2_dft_hstx_data_lpbk_o<5>
+ dl2_dft_hstx_data_lpbk_o<4> dl2_dft_hstx_data_lpbk_o<3> dl2_dft_hstx_data_lpbk_o<2> dl2_dft_hstx_data_lpbk_o<1> dl2_dft_hstx_data_lpbk_o<0> dl2_dft_hstx_higher_path_en_i dl2_dft_hstx_lower_path_en_i dl2_dft_ser_test_in_en_i dl2_dft_ser_test_n_i
+ dl2_dft_ser_test_p_i dl2_hs_ser_en_i dl2_hstx_data_i<15> dl2_hstx_data_i<14> dl2_hstx_data_i<13> dl2_hstx_data_i<12> dl2_hstx_data_i<11> dl2_hstx_data_i<10> dl2_hstx_data_i<9> dl2_hstx_data_i<8> dl2_hstx_data_i<7> dl2_hstx_data_i<6> dl2_hstx_data_i<5>
+ dl2_hstx_data_i<4> dl2_hstx_data_i<3> dl2_hstx_data_i<2> dl2_hstx_data_i<1> dl2_hstx_data_i<0> dl2_hstx_en_lptx_dis_i dl2_hstx_pwrdn_i dl2_lptx_dn_i dl2_lptx_dp_i dl2_lptx_en_i dl3_bypass_delay_line_i dl3_delay_prog_i<2> dl3_delay_prog_i<1> dl3_delay_prog_i<0>
+ dl3_dft_deser_en_i dl3_dft_hstx_data_lpbk_o<15> dl3_dft_hstx_data_lpbk_o<14> dl3_dft_hstx_data_lpbk_o<13> dl3_dft_hstx_data_lpbk_o<12> dl3_dft_hstx_data_lpbk_o<11> dl3_dft_hstx_data_lpbk_o<10> dl3_dft_hstx_data_lpbk_o<9> dl3_dft_hstx_data_lpbk_o<8>
+ dl3_dft_hstx_data_lpbk_o<7> dl3_dft_hstx_data_lpbk_o<6> dl3_dft_hstx_data_lpbk_o<5> dl3_dft_hstx_data_lpbk_o<4> dl3_dft_hstx_data_lpbk_o<3> dl3_dft_hstx_data_lpbk_o<2> dl3_dft_hstx_data_lpbk_o<1> dl3_dft_hstx_data_lpbk_o<0> dl3_dft_hstx_higher_path_en_i
+ dl3_dft_hstx_lower_path_en_i dl3_dft_ser_test_in_en_i dl3_dft_ser_test_n_i dl3_dft_ser_test_p_i dl3_hs_ser_en_i dl3_hstx_data_i<15> dl3_hstx_data_i<14> dl3_hstx_data_i<13> dl3_hstx_data_i<12> dl3_hstx_data_i<11> dl3_hstx_data_i<10> dl3_hstx_data_i<9>
+ dl3_hstx_data_i<8> dl3_hstx_data_i<7> dl3_hstx_data_i<6> dl3_hstx_data_i<5> dl3_hstx_data_i<4> dl3_hstx_data_i<3> dl3_hstx_data_i<2> dl3_hstx_data_i<1> dl3_hstx_data_i<0> dl3_hstx_en_lptx_dis_i dl3_hstx_pwrdn_i dl3_lptx_dn_i dl3_lptx_dp_i dl3_lptx_en_i
+ dphy_pwrdn_i dphy_reset_n_i en_clk_byte_i en_clk_dphy_i en_iso_vddphy_i en_ls_vddphy_i hs_ser_msb_first_en_i hstx_en_fast_trf_i hstx_ldo_vref_ai hstx_lower_imp_cal_i<2> hstx_lower_imp_cal_i<1> hstx_lower_imp_cal_i<0> hstx_upper_imp_cal_i<2>
+ hstx_upper_imp_cal_i<1> hstx_upper_imp_cal_i<0> ibias_40u_ai lptx_ldo_vref_ai lptx_vref_prog_i<4> lptx_vref_prog_i<3> lptx_vref_prog_i<2> lptx_vref_prog_i<1> lptx_vref_prog_i<0> n_mux_iq_sel_i ref_clk_dphy_i sel_dr_i tx_clk_n_o tx_clk_p_o tx_data_0_n_o
+ tx_data_0_p_o tx_data_1_n_o tx_data_1_p_o tx_data_2_n_o tx_data_2_p_o tx_data_3_n_o tx_data_3_p_o inh_bulk_n inh_bulk_p
  Xcore VDDD1V5 GNDD VDDA1V5 GNDA hstx_en_fast_trf_s ck50m4iq_p_i div_clk_dphy_i sel_dr_s clk_dphy_270_i dl1_dft_hstx_lower_path_en_s en_clk_dphy_s dl2_dft_hstx_lower_path_en_s hstx_ldo_vref_ai clk_dphy_0_i ck50m4iq_n_i n_mux_iq_sel_i lptx_ldo_vref_ai
+ dl0_dft_hstx_lower_path_en_s clk_dphy_90_i cl_dft_hstx_lower_path_en_s ref_clk_dphy_i dl3_dft_hstx_lower_path_en_s ibias_40u_ai clk_dphy_180_i dl3_dft_hstx_data_lpbk_s<15> dl3_dft_hstx_data_lpbk_s<14> dl3_dft_hstx_data_lpbk_s<13> dl3_dft_hstx_data_lpbk_s<12>
+ dl3_dft_hstx_data_lpbk_s<11> dl3_dft_hstx_data_lpbk_s<10> dl3_dft_hstx_data_lpbk_s<9> dl3_dft_hstx_data_lpbk_s<8> dl3_dft_hstx_data_lpbk_s<7> dl3_dft_hstx_data_lpbk_s<6> dl3_dft_hstx_data_lpbk_s<5> dl3_dft_hstx_data_lpbk_s<4> dl3_dft_hstx_data_lpbk_s<3>
+ dl3_dft_hstx_data_lpbk_s<2> dl3_dft_hstx_data_lpbk_s<1> dl3_dft_hstx_data_lpbk_s<0> dl1_dft_hstx_data_lpbk_s<15> dl1_dft_hstx_data_lpbk_s<14> dl1_dft_hstx_data_lpbk_s<13> dl1_dft_hstx_data_lpbk_s<12> dl1_dft_hstx_data_lpbk_s<11> dl1_dft_hstx_data_lpbk_s<10>
+ dl1_dft_hstx_data_lpbk_s<9> dl1_dft_hstx_data_lpbk_s<8> dl1_dft_hstx_data_lpbk_s<7> dl1_dft_hstx_data_lpbk_s<6> dl1_dft_hstx_data_lpbk_s<5> dl1_dft_hstx_data_lpbk_s<4> dl1_dft_hstx_data_lpbk_s<3> dl1_dft_hstx_data_lpbk_s<2> dl1_dft_hstx_data_lpbk_s<1>
+ dl1_dft_hstx_data_lpbk_s<0> tx_data_3_n_o tx_data_1_p_o tx_data_1_n_o clk_byte_s tx_data_0_p_o tx_data_0_n_o tx_clk_p_o dl2_dft_hstx_data_lpbk_s<15> dl2_dft_hstx_data_lpbk_s<14> dl2_dft_hstx_data_lpbk_s<13> dl2_dft_hstx_data_lpbk_s<12>
+ dl2_dft_hstx_data_lpbk_s<11> dl2_dft_hstx_data_lpbk_s<10> dl2_dft_hstx_data_lpbk_s<9> dl2_dft_hstx_data_lpbk_s<8> dl2_dft_hstx_data_lpbk_s<7> dl2_dft_hstx_data_lpbk_s<6> dl2_dft_hstx_data_lpbk_s<5> dl2_dft_hstx_data_lpbk_s<4> dl2_dft_hstx_data_lpbk_s<3>
+ dl2_dft_hstx_data_lpbk_s<2> dl2_dft_hstx_data_lpbk_s<1> dl2_dft_hstx_data_lpbk_s<0> cl_dft_hstx_data_lpbk_s<15> cl_dft_hstx_data_lpbk_s<14> cl_dft_hstx_data_lpbk_s<13> cl_dft_hstx_data_lpbk_s<12> cl_dft_hstx_data_lpbk_s<11> cl_dft_hstx_data_lpbk_s<10>
+ cl_dft_hstx_data_lpbk_s<9> cl_dft_hstx_data_lpbk_s<8> cl_dft_hstx_data_lpbk_s<7> cl_dft_hstx_data_lpbk_s<6> cl_dft_hstx_data_lpbk_s<5> cl_dft_hstx_data_lpbk_s<4> cl_dft_hstx_data_lpbk_s<3> cl_dft_hstx_data_lpbk_s<2> cl_dft_hstx_data_lpbk_s<1>
+ cl_dft_hstx_data_lpbk_s<0> dl0_dft_hstx_data_lpbk_s<15> dl0_dft_hstx_data_lpbk_s<14> dl0_dft_hstx_data_lpbk_s<13> dl0_dft_hstx_data_lpbk_s<12> dl0_dft_hstx_data_lpbk_s<11> dl0_dft_hstx_data_lpbk_s<10> dl0_dft_hstx_data_lpbk_s<9> dl0_dft_hstx_data_lpbk_s<8>
+ dl0_dft_hstx_data_lpbk_s<7> dl0_dft_hstx_data_lpbk_s<6> dl0_dft_hstx_data_lpbk_s<5> dl0_dft_hstx_data_lpbk_s<4> dl0_dft_hstx_data_lpbk_s<3> dl0_dft_hstx_data_lpbk_s<2> dl0_dft_hstx_data_lpbk_s<1> dl0_dft_hstx_data_lpbk_s<0> tx_data_2_p_o tx_clk_n_o
+ tx_data_2_n_o dft_ana_test_ao tx_data_3_p_o dl3_hstx_data_s<15> dl3_hstx_data_s<14> dl3_hstx_data_s<13> dl3_hstx_data_s<12> dl3_hstx_data_s<11> dl3_hstx_data_s<10> dl3_hstx_data_s<9> dl3_hstx_data_s<8> dl3_hstx_data_s<7> dl3_hstx_data_s<6> dl3_hstx_data_s<5>
+ dl3_hstx_data_s<4> dl3_hstx_data_s<3> dl3_hstx_data_s<2> dl3_hstx_data_s<1> dl3_hstx_data_s<0> dl3_hs_ser_en_s dl3_hstx_pwrdn_s dl3_hstx_en_lptx_dis_s dl3_lptx_en_s dl3_lptx_dp_s dl3_lptx_dn_s dl3_dft_deser_en_s dl3_bypass_delay_line_s dl3_dft_ser_test_in_en_s
+ dl3_dft_ser_test_n_s dl3_dft_ser_test_p_s dl3_delay_prog_s<2> dl3_delay_prog_s<1> dl3_delay_prog_s<0> dl1_hstx_data_s<15> dl1_hstx_data_s<14> dl1_hstx_data_s<13> dl1_hstx_data_s<12> dl1_hstx_data_s<11> dl1_hstx_data_s<10> dl1_hstx_data_s<9> dl1_hstx_data_s<8>
+ dl1_hstx_data_s<7> dl1_hstx_data_s<6> dl1_hstx_data_s<5> dl1_hstx_data_s<4> dl1_hstx_data_s<3> dl1_hstx_data_s<2> dl1_hstx_data_s<1> dl1_hstx_data_s<0> dl1_dft_deser_en_s dl1_hstx_en_lptx_dis_s dl1_hstx_pwrdn_s dl1_lptx_dn_s dl1_dft_ser_test_n_s
+ dl1_delay_prog_s<2> dl1_delay_prog_s<1> dl1_delay_prog_s<0> dl1_bypass_delay_line_s dl0_hstx_data_s<15> dl0_hstx_data_s<14> dl0_hstx_data_s<13> dl0_hstx_data_s<12> dl0_hstx_data_s<11> dl0_hstx_data_s<10> dl0_hstx_data_s<9> dl0_hstx_data_s<8> dl0_hstx_data_s<7>
+ dl0_hstx_data_s<6> dl0_hstx_data_s<5> dl0_hstx_data_s<4> dl0_hstx_data_s<3> dl0_hstx_data_s<2> dl0_hstx_data_s<1> dl0_hstx_data_s<0> dl1_lptx_dp_s dl1_lptx_en_s dl1_hs_ser_en_s lptx_vref_prog_s<4> lptx_vref_prog_s<3> lptx_vref_prog_s<2> lptx_vref_prog_s<1>
+ lptx_vref_prog_s<0> en_ls_vddphy_i dl0_dft_ser_test_p_s cl_dft_ser_test_in_en_s dl2_dft_ser_test_p_s dl2_dft_ser_test_in_en_s dft_ana_test_en_s dl2_dft_ser_test_n_s dl0_dft_ser_test_in_en_s dl2_hstx_en_lptx_dis_s cl_lptx_dp_s dl2_lptx_dn_s
+ hstx_lower_imp_cal_s<2> hstx_lower_imp_cal_s<1> hstx_lower_imp_cal_s<0> dphy_reset_n_s dl0_dft_ser_test_n_s dl0_delay_prog_s<2> dl0_delay_prog_s<1> dl0_delay_prog_s<0> dl0_lptx_dn_s cl_hstx_data_s<15> cl_hstx_data_s<14> cl_hstx_data_s<13> cl_hstx_data_s<12>
+ cl_hstx_data_s<11> cl_hstx_data_s<10> cl_hstx_data_s<9> cl_hstx_data_s<8> cl_hstx_data_s<7> cl_hstx_data_s<6> cl_hstx_data_s<5> cl_hstx_data_s<4> cl_hstx_data_s<3> cl_hstx_data_s<2> cl_hstx_data_s<1> cl_hstx_data_s<0> cl_lptx_dn_s dl2_hstx_data_s<15>
+ dl2_hstx_data_s<14> dl2_hstx_data_s<13> dl2_hstx_data_s<12> dl2_hstx_data_s<11> dl2_hstx_data_s<10> dl2_hstx_data_s<9> dl2_hstx_data_s<8> dl2_hstx_data_s<7> dl2_hstx_data_s<6> dl2_hstx_data_s<5> dl2_hstx_data_s<4> dl2_hstx_data_s<3> dl2_hstx_data_s<2>
+ dl2_hstx_data_s<1> dl2_hstx_data_s<0> dl2_lptx_en_s cl_hs_ser_en_s cl_hstx_en_lptx_dis_s dl2_lptx_dp_s cl_delay_prog_s<2> cl_delay_prog_s<1> cl_delay_prog_s<0> dl2_delay_prog_s<2> dl2_delay_prog_s<1> dl2_delay_prog_s<0> cl_hstx_pwrdn_s cl_dft_ser_test_p_s
+ dl2_hs_ser_en_s cl_lptx_en_s dl2_hstx_pwrdn_s dft_pll_clks_2_cl_en_s cl_dft_deser_en_s cl_bypass_delay_line_s dl0_bypass_delay_line_s dl0_dft_deser_en_s dl2_dft_deser_en_s dl2_bypass_delay_line_s dphy_pwrdn_s cl_dft_ser_test_n_s dl1_dft_ser_test_p_s
+ dl1_dft_ser_test_in_en_s dl0_hstx_pwrdn_s dl0_hs_ser_en_s hstx_upper_imp_cal_s<2> hstx_upper_imp_cal_s<1> hstx_upper_imp_cal_s<0> dft_dphy_ocdldo_res_dis_s dl0_lptx_dp_s dl0_lptx_en_s dl0_hstx_en_lptx_dis_s hs_ser_msb_first_en_s dft_ana_test_out_dphy_sel_s<3>
+ dft_ana_test_out_dphy_sel_s<2> dft_ana_test_out_dphy_sel_s<1> dft_ana_test_out_dphy_sel_s<0> en_iso_vddphy_i inh_bulk_n inh_bulk_p phy_ana_core
  Xsts VDDD1V5 GNDD cl_bypass_delay_line_i cl_bypass_delay_line_s cl_delay_prog_i<2> cl_delay_prog_i<1> cl_delay_prog_i<0> cl_delay_prog_s<2> cl_delay_prog_s<1> cl_delay_prog_s<0> cl_dft_deser_en_i cl_dft_deser_en_s cl_dft_hstx_data_lpbk_s<15>
+ cl_dft_hstx_data_lpbk_s<14> cl_dft_hstx_data_lpbk_s<13> cl_dft_hstx_data_lpbk_s<12> cl_dft_hstx_data_lpbk_s<11> cl_dft_hstx_data_lpbk_s<10> cl_dft_hstx_data_lpbk_s<9> cl_dft_hstx_data_lpbk_s<8> cl_dft_hstx_data_lpbk_s<7> cl_dft_hstx_data_lpbk_s<6>
+ cl_dft_hstx_data_lpbk_s<5> cl_dft_hstx_data_lpbk_s<4> cl_dft_hstx_data_lpbk_s<3> cl_dft_hstx_data_lpbk_s<2> cl_dft_hstx_data_lpbk_s<1> cl_dft_hstx_data_lpbk_s<0> cl_dft_hstx_data_lpbk_o<15> cl_dft_hstx_data_lpbk_o<14> cl_dft_hstx_data_lpbk_o<13>
+ cl_dft_hstx_data_lpbk_o<12> cl_dft_hstx_data_lpbk_o<11> cl_dft_hstx_data_lpbk_o<10> cl_dft_hstx_data_lpbk_o<9> cl_dft_hstx_data_lpbk_o<8> cl_dft_hstx_data_lpbk_o<7> cl_dft_hstx_data_lpbk_o<6> cl_dft_hstx_data_lpbk_o<5> cl_dft_hstx_data_lpbk_o<4>
+ cl_dft_hstx_data_lpbk_o<3> cl_dft_hstx_data_lpbk_o<2> cl_dft_hstx_data_lpbk_o<1> cl_dft_hstx_data_lpbk_o<0> cl_dft_hstx_higher_path_en_i cl_dft_hstx_lower_path_en_i cl_dft_hstx_lower_path_en_s cl_dft_ser_test_in_en_i cl_dft_ser_test_in_en_s cl_dft_ser_test_n_i
+ cl_dft_ser_test_n_s cl_dft_ser_test_p_i cl_dft_ser_test_p_s cl_hs_ser_en_i cl_hs_ser_en_s cl_hstx_data_i<15> cl_hstx_data_i<14> cl_hstx_data_i<13> cl_hstx_data_i<12> cl_hstx_data_i<11> cl_hstx_data_i<10> cl_hstx_data_i<9> cl_hstx_data_i<8> cl_hstx_data_i<7>
+ cl_hstx_data_i<6> cl_hstx_data_i<5> cl_hstx_data_i<4> cl_hstx_data_i<3> cl_hstx_data_i<2> cl_hstx_data_i<1> cl_hstx_data_i<0> cl_hstx_data_s<15> cl_hstx_data_s<14> cl_hstx_data_s<13> cl_hstx_data_s<12> cl_hstx_data_s<11> cl_hstx_data_s<10> cl_hstx_data_s<9>
+ cl_hstx_data_s<8> cl_hstx_data_s<7> cl_hstx_data_s<6> cl_hstx_data_s<5> cl_hstx_data_s<4> cl_hstx_data_s<3> cl_hstx_data_s<2> cl_hstx_data_s<1> cl_hstx_data_s<0> cl_hstx_en_lptx_dis_i cl_hstx_en_lptx_dis_s cl_hstx_pwrdn_i cl_hstx_pwrdn_s cl_lptx_dn_i
+ cl_lptx_dn_s cl_lptx_dp_i cl_lptx_dp_s cl_lptx_en_i cl_lptx_en_s clk_byte_s clk_byte_o dft_ana_test_en_i dft_ana_test_en_s dft_ana_test_out_dphy_sel_i<3> dft_ana_test_out_dphy_sel_i<2> dft_ana_test_out_dphy_sel_i<1> dft_ana_test_out_dphy_sel_i<0>
+ dft_ana_test_out_dphy_sel_s<3> dft_ana_test_out_dphy_sel_s<2> dft_ana_test_out_dphy_sel_s<1> dft_ana_test_out_dphy_sel_s<0> dft_dphy_ocdldo_res_dis_i dft_dphy_ocdldo_res_dis_s dft_pll_clks_2_cl_en_i dft_pll_clks_2_cl_en_s dft_scan_mode_i dl0_bypass_delay_line_i
+ dl0_bypass_delay_line_s dl0_delay_prog_i<2> dl0_delay_prog_i<1> dl0_delay_prog_i<0> dl0_delay_prog_s<2> dl0_delay_prog_s<1> dl0_delay_prog_s<0> dl0_dft_deser_en_i dl0_dft_deser_en_s dl0_dft_hstx_data_lpbk_s<15> dl0_dft_hstx_data_lpbk_s<14>
+ dl0_dft_hstx_data_lpbk_s<13> dl0_dft_hstx_data_lpbk_s<12> dl0_dft_hstx_data_lpbk_s<11> dl0_dft_hstx_data_lpbk_s<10> dl0_dft_hstx_data_lpbk_s<9> dl0_dft_hstx_data_lpbk_s<8> dl0_dft_hstx_data_lpbk_s<7> dl0_dft_hstx_data_lpbk_s<6> dl0_dft_hstx_data_lpbk_s<5>
+ dl0_dft_hstx_data_lpbk_s<4> dl0_dft_hstx_data_lpbk_s<3> dl0_dft_hstx_data_lpbk_s<2> dl0_dft_hstx_data_lpbk_s<1> dl0_dft_hstx_data_lpbk_s<0> dl0_dft_hstx_data_lpbk_o<15> dl0_dft_hstx_data_lpbk_o<14> dl0_dft_hstx_data_lpbk_o<13> dl0_dft_hstx_data_lpbk_o<12>
+ dl0_dft_hstx_data_lpbk_o<11> dl0_dft_hstx_data_lpbk_o<10> dl0_dft_hstx_data_lpbk_o<9> dl0_dft_hstx_data_lpbk_o<8> dl0_dft_hstx_data_lpbk_o<7> dl0_dft_hstx_data_lpbk_o<6> dl0_dft_hstx_data_lpbk_o<5> dl0_dft_hstx_data_lpbk_o<4> dl0_dft_hstx_data_lpbk_o<3>
+ dl0_dft_hstx_data_lpbk_o<2> dl0_dft_hstx_data_lpbk_o<1> dl0_dft_hstx_data_lpbk_o<0> dl0_dft_hstx_higher_path_en_i dl0_dft_hstx_lower_path_en_i dl0_dft_hstx_lower_path_en_s dl0_dft_ser_test_in_en_i dl0_dft_ser_test_in_en_s dl0_dft_ser_test_n_i
+ dl0_dft_ser_test_n_s dl0_dft_ser_test_p_i dl0_dft_ser_test_p_s dl0_hs_ser_en_i dl0_hs_ser_en_s dl0_hstx_data_i<15> dl0_hstx_data_i<14> dl0_hstx_data_i<13> dl0_hstx_data_i<12> dl0_hstx_data_i<11> dl0_hstx_data_i<10> dl0_hstx_data_i<9> dl0_hstx_data_i<8>
+ dl0_hstx_data_i<7> dl0_hstx_data_i<6> dl0_hstx_data_i<5> dl0_hstx_data_i<4> dl0_hstx_data_i<3> dl0_hstx_data_i<2> dl0_hstx_data_i<1> dl0_hstx_data_i<0> dl0_hstx_data_s<15> dl0_hstx_data_s<14> dl0_hstx_data_s<13> dl0_hstx_data_s<12> dl0_hstx_data_s<11>
+ dl0_hstx_data_s<10> dl0_hstx_data_s<9> dl0_hstx_data_s<8> dl0_hstx_data_s<7> dl0_hstx_data_s<6> dl0_hstx_data_s<5> dl0_hstx_data_s<4> dl0_hstx_data_s<3> dl0_hstx_data_s<2> dl0_hstx_data_s<1> dl0_hstx_data_s<0> dl0_hstx_en_lptx_dis_i dl0_hstx_en_lptx_dis_s
+ dl0_hstx_pwrdn_i dl0_hstx_pwrdn_s dl0_lptx_dn_i dl0_lptx_dn_s dl0_lptx_dp_i dl0_lptx_dp_s dl0_lptx_en_i dl0_lptx_en_s dl1_bypass_delay_line_i dl1_bypass_delay_line_s dl1_delay_prog_i<2> dl1_delay_prog_i<1> dl1_delay_prog_i<0> dl1_delay_prog_s<2>
+ dl1_delay_prog_s<1> dl1_delay_prog_s<0> dl1_dft_deser_en_i dl1_dft_deser_en_s dl1_dft_hstx_data_lpbk_s<15> dl1_dft_hstx_data_lpbk_s<14> dl1_dft_hstx_data_lpbk_s<13> dl1_dft_hstx_data_lpbk_s<12> dl1_dft_hstx_data_lpbk_s<11> dl1_dft_hstx_data_lpbk_s<10>
+ dl1_dft_hstx_data_lpbk_s<9> dl1_dft_hstx_data_lpbk_s<8> dl1_dft_hstx_data_lpbk_s<7> dl1_dft_hstx_data_lpbk_s<6> dl1_dft_hstx_data_lpbk_s<5> dl1_dft_hstx_data_lpbk_s<4> dl1_dft_hstx_data_lpbk_s<3> dl1_dft_hstx_data_lpbk_s<2> dl1_dft_hstx_data_lpbk_s<1>
+ dl1_dft_hstx_data_lpbk_s<0> dl1_dft_hstx_data_lpbk_o<15> dl1_dft_hstx_data_lpbk_o<14> dl1_dft_hstx_data_lpbk_o<13> dl1_dft_hstx_data_lpbk_o<12> dl1_dft_hstx_data_lpbk_o<11> dl1_dft_hstx_data_lpbk_o<10> dl1_dft_hstx_data_lpbk_o<9> dl1_dft_hstx_data_lpbk_o<8>
+ dl1_dft_hstx_data_lpbk_o<7> dl1_dft_hstx_data_lpbk_o<6> dl1_dft_hstx_data_lpbk_o<5> dl1_dft_hstx_data_lpbk_o<4> dl1_dft_hstx_data_lpbk_o<3> dl1_dft_hstx_data_lpbk_o<2> dl1_dft_hstx_data_lpbk_o<1> dl1_dft_hstx_data_lpbk_o<0> dl1_dft_hstx_higher_path_en_i
+ dl1_dft_hstx_lower_path_en_i dl1_dft_hstx_lower_path_en_s dl1_dft_ser_test_in_en_i dl1_dft_ser_test_in_en_s dl1_dft_ser_test_n_i dl1_dft_ser_test_n_s dl1_dft_ser_test_p_i dl1_dft_ser_test_p_s dl1_hs_ser_en_i dl1_hs_ser_en_s dl1_hstx_data_i<15>
+ dl1_hstx_data_i<14> dl1_hstx_data_i<13> dl1_hstx_data_i<12> dl1_hstx_data_i<11> dl1_hstx_data_i<10> dl1_hstx_data_i<9> dl1_hstx_data_i<8> dl1_hstx_data_i<7> dl1_hstx_data_i<6> dl1_hstx_data_i<5> dl1_hstx_data_i<4> dl1_hstx_data_i<3> dl1_hstx_data_i<2>
+ dl1_hstx_data_i<1> dl1_hstx_data_i<0> dl1_hstx_data_s<15> dl1_hstx_data_s<14> dl1_hstx_data_s<13> dl1_hstx_data_s<12> dl1_hstx_data_s<11> dl1_hstx_data_s<10> dl1_hstx_data_s<9> dl1_hstx_data_s<8> dl1_hstx_data_s<7> dl1_hstx_data_s<6> dl1_hstx_data_s<5>
+ dl1_hstx_data_s<4> dl1_hstx_data_s<3> dl1_hstx_data_s<2> dl1_hstx_data_s<1> dl1_hstx_data_s<0> dl1_hstx_en_lptx_dis_i dl1_hstx_en_lptx_dis_s dl1_hstx_pwrdn_i dl1_hstx_pwrdn_s dl1_lptx_dn_i dl1_lptx_dn_s dl1_lptx_dp_i dl1_lptx_dp_s dl1_lptx_en_i dl1_lptx_en_s
+ dl2_bypass_delay_line_i dl2_bypass_delay_line_s dl2_delay_prog_i<2> dl2_delay_prog_i<1> dl2_delay_prog_i<0> dl2_delay_prog_s<2> dl2_delay_prog_s<1> dl2_delay_prog_s<0> dl2_dft_deser_en_i dl2_dft_deser_en_s dl2_dft_hstx_data_lpbk_s<15>
+ dl2_dft_hstx_data_lpbk_s<14> dl2_dft_hstx_data_lpbk_s<13> dl2_dft_hstx_data_lpbk_s<12> dl2_dft_hstx_data_lpbk_s<11> dl2_dft_hstx_data_lpbk_s<10> dl2_dft_hstx_data_lpbk_s<9> dl2_dft_hstx_data_lpbk_s<8> dl2_dft_hstx_data_lpbk_s<7> dl2_dft_hstx_data_lpbk_s<6>
+ dl2_dft_hstx_data_lpbk_s<5> dl2_dft_hstx_data_lpbk_s<4> dl2_dft_hstx_data_lpbk_s<3> dl2_dft_hstx_data_lpbk_s<2> dl2_dft_hstx_data_lpbk_s<1> dl2_dft_hstx_data_lpbk_s<0> dl2_dft_hstx_data_lpbk_o<15> dl2_dft_hstx_data_lpbk_o<14> dl2_dft_hstx_data_lpbk_o<13>
+ dl2_dft_hstx_data_lpbk_o<12> dl2_dft_hstx_data_lpbk_o<11> dl2_dft_hstx_data_lpbk_o<10> dl2_dft_hstx_data_lpbk_o<9> dl2_dft_hstx_data_lpbk_o<8> dl2_dft_hstx_data_lpbk_o<7> dl2_dft_hstx_data_lpbk_o<6> dl2_dft_hstx_data_lpbk_o<5> dl2_dft_hstx_data_lpbk_o<4>
+ dl2_dft_hstx_data_lpbk_o<3> dl2_dft_hstx_data_lpbk_o<2> dl2_dft_hstx_data_lpbk_o<1> dl2_dft_hstx_data_lpbk_o<0> dl2_dft_hstx_higher_path_en_i dl2_dft_hstx_lower_path_en_i dl2_dft_hstx_lower_path_en_s dl2_dft_ser_test_in_en_i dl2_dft_ser_test_in_en_s
+ dl2_dft_ser_test_n_i dl2_dft_ser_test_n_s dl2_dft_ser_test_p_i dl2_dft_ser_test_p_s dl2_hs_ser_en_i dl2_hs_ser_en_s dl2_hstx_data_i<15> dl2_hstx_data_i<14> dl2_hstx_data_i<13> dl2_hstx_data_i<12> dl2_hstx_data_i<11> dl2_hstx_data_i<10> dl2_hstx_data_i<9>
+ dl2_hstx_data_i<8> dl2_hstx_data_i<7> dl2_hstx_data_i<6> dl2_hstx_data_i<5> dl2_hstx_data_i<4> dl2_hstx_data_i<3> dl2_hstx_data_i<2> dl2_hstx_data_i<1> dl2_hstx_data_i<0> dl2_hstx_data_s<15> dl2_hstx_data_s<14> dl2_hstx_data_s<13> dl2_hstx_data_s<12>
+ dl2_hstx_data_s<11> dl2_hstx_data_s<10> dl2_hstx_data_s<9> dl2_hstx_data_s<8> dl2_hstx_data_s<7> dl2_hstx_data_s<6> dl2_hstx_data_s<5> dl2_hstx_data_s<4> dl2_hstx_data_s<3> dl2_hstx_data_s<2> dl2_hstx_data_s<1> dl2_hstx_data_s<0> dl2_hstx_en_lptx_dis_i
+ dl2_hstx_en_lptx_dis_s dl2_hstx_pwrdn_i dl2_hstx_pwrdn_s dl2_lptx_dn_i dl2_lptx_dn_s dl2_lptx_dp_i dl2_lptx_dp_s dl2_lptx_en_i dl2_lptx_en_s dl3_bypass_delay_line_i dl3_bypass_delay_line_s dl3_delay_prog_i<2> dl3_delay_prog_i<1> dl3_delay_prog_i<0>
+ dl3_delay_prog_s<2> dl3_delay_prog_s<1> dl3_delay_prog_s<0> dl3_dft_deser_en_i dl3_dft_deser_en_s dl3_dft_hstx_data_lpbk_s<15> dl3_dft_hstx_data_lpbk_s<14> dl3_dft_hstx_data_lpbk_s<13> dl3_dft_hstx_data_lpbk_s<12> dl3_dft_hstx_data_lpbk_s<11>
+ dl3_dft_hstx_data_lpbk_s<10> dl3_dft_hstx_data_lpbk_s<9> dl3_dft_hstx_data_lpbk_s<8> dl3_dft_hstx_data_lpbk_s<7> dl3_dft_hstx_data_lpbk_s<6> dl3_dft_hstx_data_lpbk_s<5> dl3_dft_hstx_data_lpbk_s<4> dl3_dft_hstx_data_lpbk_s<3> dl3_dft_hstx_data_lpbk_s<2>
+ dl3_dft_hstx_data_lpbk_s<1> dl3_dft_hstx_data_lpbk_s<0> dl3_dft_hstx_data_lpbk_o<15> dl3_dft_hstx_data_lpbk_o<14> dl3_dft_hstx_data_lpbk_o<13> dl3_dft_hstx_data_lpbk_o<12> dl3_dft_hstx_data_lpbk_o<11> dl3_dft_hstx_data_lpbk_o<10> dl3_dft_hstx_data_lpbk_o<9>
+ dl3_dft_hstx_data_lpbk_o<8> dl3_dft_hstx_data_lpbk_o<7> dl3_dft_hstx_data_lpbk_o<6> dl3_dft_hstx_data_lpbk_o<5> dl3_dft_hstx_data_lpbk_o<4> dl3_dft_hstx_data_lpbk_o<3> dl3_dft_hstx_data_lpbk_o<2> dl3_dft_hstx_data_lpbk_o<1> dl3_dft_hstx_data_lpbk_o<0>
+ dl3_dft_hstx_higher_path_en_i dl3_dft_hstx_lower_path_en_i dl3_dft_hstx_lower_path_en_s dl3_dft_ser_test_in_en_i dl3_dft_ser_test_in_en_s dl3_dft_ser_test_n_i dl3_dft_ser_test_n_s dl3_dft_ser_test_p_i dl3_dft_ser_test_p_s dl3_hs_ser_en_i dl3_hs_ser_en_s
+ dl3_hstx_data_i<15> dl3_hstx_data_i<14> dl3_hstx_data_i<13> dl3_hstx_data_i<12> dl3_hstx_data_i<11> dl3_hstx_data_i<10> dl3_hstx_data_i<9> dl3_hstx_data_i<8> dl3_hstx_data_i<7> dl3_hstx_data_i<6> dl3_hstx_data_i<5> dl3_hstx_data_i<4> dl3_hstx_data_i<3>
+ dl3_hstx_data_i<2> dl3_hstx_data_i<1> dl3_hstx_data_i<0> dl3_hstx_data_s<15> dl3_hstx_data_s<14> dl3_hstx_data_s<13> dl3_hstx_data_s<12> dl3_hstx_data_s<11> dl3_hstx_data_s<10> dl3_hstx_data_s<9> dl3_hstx_data_s<8> dl3_hstx_data_s<7> dl3_hstx_data_s<6>
+ dl3_hstx_data_s<5> dl3_hstx_data_s<4> dl3_hstx_data_s<3> dl3_hstx_data_s<2> dl3_hstx_data_s<1> dl3_hstx_data_s<0> dl3_hstx_en_lptx_dis_i dl3_hstx_en_lptx_dis_s dl3_hstx_pwrdn_i dl3_hstx_pwrdn_s dl3_lptx_dn_i dl3_lptx_dn_s dl3_lptx_dp_i dl3_lptx_dp_s
+ dl3_lptx_en_i dl3_lptx_en_s dphy_pwrdn_i dphy_pwrdn_s dphy_reset_n_i dphy_reset_n_s en_clk_byte_i en_clk_dphy_i en_clk_dphy_s hs_ser_msb_first_en_i hs_ser_msb_first_en_s hstx_en_fast_trf_i hstx_en_fast_trf_s hstx_lower_imp_cal_i<2> hstx_lower_imp_cal_i<1>
+ hstx_lower_imp_cal_i<0> hstx_lower_imp_cal_s<2> hstx_lower_imp_cal_s<1> hstx_lower_imp_cal_s<0> hstx_upper_imp_cal_i<2> hstx_upper_imp_cal_i<1> hstx_upper_imp_cal_i<0> hstx_upper_imp_cal_s<2> hstx_upper_imp_cal_s<1> hstx_upper_imp_cal_s<0> lptx_vref_prog_i<4>
+ lptx_vref_prog_i<3> lptx_vref_prog_i<2> lptx_vref_prog_i<1> lptx_vref_prog_i<0> lptx_vref_prog_s<4> lptx_vref_prog_s<3> lptx_vref_prog_s<2> lptx_vref_prog_s<1> lptx_vref_prog_s<0> sel_dr_i sel_dr_s inh_bulk_n inh_bulk_p phy_ana_sts
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: cell_bg_precond
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT cell_bg_precond disable ibias_n_6p4u_ao ibias_p_40u_ao ref_0p4_ao ref_0p6_ao refin inh_bulkn inh_bulkpanalog inh_hsupanalog inh_lSup
  M73 net22 net20 net027 inh_bulkn NANA W='400n' L='400n' M='1'
  M32 net016 net07 inh_lSup inh_bulkn NANA W='400n' L='400n' M='1'
  M47 net027 net027 inh_lSup inh_bulkn NANA W='400n' L='400n' M='1'
  M23 net016 net017 inh_lSup inh_bulkn NANA W='400n' L='400n' M='1'
  M24 net21 net017 inh_lSup inh_bulkn NANA W='400n' L='400n' M='1'
  M19 net022 net049 net016 inh_bulkn NANA W='400n' L='400n' M='1'
  M78 inh_lSup inh_lSup inh_hsupanalog inh_bulkn NANA W='400n' L='400n' M='1'
  M33 net049 net07 inh_lSup inh_bulkn NANA W='400n' L='400n' M='1'
  M15 net045 net07 inh_lSup inh_bulkn NANA W='400n' L='400n' M='1'
  M14 net044 net045 inh_lSup inh_bulkn NANA W='400n' L='400n' M='1'
  M13 ibias_n_6p4u_ao net045 inh_lSup inh_bulkn NANA W='400n' L='400n' M='10'
  M16 net045 net20 net044 inh_bulkn NANA W='400n' L='400n' M='1'
  M10 ref_0p4_ao net07 inh_lSup inh_bulkn NANA W='400n' L='400n' M='1'
  M9 inh_lSup inh_lSup ref_0p4_ao inh_bulkn NANA W='400n' L='400n' M='1'
  M4 ref_0p6_ao net07 inh_lSup inh_bulkn NANA W='400n' L='400n' M='1'
  M77 inh_lSup inh_lSup ref_0p6_ao inh_bulkn NANA W='400n' L='400n' M='1'
  M61 net07 net20 inh_lSup inh_bulkn NANA W='400n' L='400n' M='1'
  M55 net20 disable inh_lSup inh_bulkn NANA W='400n' L='400n' M='1'
  M25 net053 net18 net21 inh_bulkn NANA W='400n' L='400n' M='8'
  M28 net017 net07 inh_lSup inh_bulkn NANA W='400n' L='400n' M='1'
  M45 net28 net027 net54 inh_bulkn NANA W='400n' L='400n' M='2'
  M29 net21 net20 net017 inh_bulkn NANA W='400n' L='400n' M='1'
  M20 net019 net077 net016 inh_bulkn NANA W='400n' L='400n' M='1'
  C0 net019 net049 C='30f'
  R8 net057 inh_lSup R='20K'
  R10 net049 net088 R='20K'
  R9 net056 ref_0p6_ao R='20K'
  R5 ref_0p6_ao ref_0p4_ao R='20K'
  R2 refin net077 R='1K'
  R7 ref_0p4_ao net057 R='20K'
  R12 net054 net056 R='20K'
  R11 net54 inh_lSup R='50K'
  R13 net088 net054 R='20K'
  M75 net18 net20 inh_hsupanalog inh_bulkpanalog PANA W='400n' L='400n' M='8'
  M84 net19 net20 inh_hsupanalog inh_bulkpanalog PANA W='400n' L='400n' M='8'
  M21 net022 net16 inh_hsupanalog inh_bulkpanalog PANA W='400n' L='400n' M='1'
  M0 net026 net026 net25 inh_bulkpanalog PANA W='400n' L='1.2u' M='1'
  M27 net29 net19 inh_hsupanalog inh_bulkpanalog PANA W='400n' L='400n' M='2'
  M79 net28 net07 net18 inh_bulkpanalog PANA W='400n' L='400n' M='8'
  M11 ibias_p_40u_ao net019 inh_hsupanalog inh_bulkpanalog PANA W='400n' L='400n' M='20'
  M12 net019 net20 inh_hsupanalog inh_bulkpanalog PANA W='400n' L='400n' M='8'
  M7 net044 net019 inh_hsupanalog inh_bulkpanalog PANA W='400n' L='400n' M='1'
  M5 net049 net019 inh_hsupanalog inh_bulkpanalog PANA W='400n' L='400n' M='5'
  M59 net28 net18 net29 inh_bulkpanalog PANA W='400n' L='400n' M='8'
  M22 net019 net16 inh_hsupanalog inh_bulkpanalog PANA W='400n' L='400n' M='1'
  M50 net22 net19 inh_hsupanalog inh_bulkpanalog PANA W='400n' L='400n' M='2'
  M51 net25 net25 inh_hsupanalog inh_bulkpanalog PANA W='400n' L='1.2u' M='1'
  M31 net022 net20 inh_hsupanalog inh_bulkpanalog PANA W='400n' L='400n' M='8'
  M30 net022 net07 net16 inh_bulkpanalog PANA W='400n' L='400n' M='8'
  M70 net07 net20 inh_hsupanalog inh_bulkpanalog PANA W='1.2u' L='400n' M='1'
  M83 net20 disable inh_hsupanalog inh_bulkpanalog PANA W='1.2u' L='400n' M='1'
  M80 net29 net07 net19 inh_bulkpanalog PANA W='400n' L='400n' M='8'
  M1 net22 net22 net026 inh_bulkpanalog PANA W='400n' L='1.2u' M='1'
  M26 net053 net19 inh_hsupanalog inh_bulkpanalog PANA W='400n' L='400n' M='2'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: phy_local
** Cell name: cell_dll_wrapper
** View name: schematic_va
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT cell_dll_wrapper clk_okay_o clk_dphy_0_o clk_dphy_90_o clk_dphy_180_o clk_dphy_270_o lock_o en_1GHz_quad_i ibias_5u_n_ai inh_lSup
  XI3 clk_okay_o net15 net14 clk_dphy_0_o clk_dphy_90_o clk_dphy_180_o clk_dphy_270_o net12 lock_o net13 net11 en_1GHz_quad_i inh_lSup va_pll_model vhigh='1.5' trf='3e-11'
.ENDS
** End of subcircuit definition.

** Subcircuit
** ----------
** Library name: saradc_11bit_testbench
** Cell name: supplies
** View name: schematic
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
.SUBCKT supplies inh_bulkn inh_bulkpanalog inh_bulkpcore inh_hsupanalog inh_hsupcore inh_lSup
  V0 net7 inh_lSup DC='vsup2v5' PULSE( '0' 'vsup2v5' 'td_ps' 'tr_ps' '1m' '9' '10' )
  V1 net8 inh_lSup DC='vsup1v5' PULSE( '0' 'vsup1v5' 'td_ps' 'tr_ps' '1m' '9' '10' )
  R5 0 inh_lSup R='1m'
  R4 inh_hsupcore net8 R='rhsupcore'
  R3 inh_hsupanalog net7 R='rhsupanalog'
  R2 inh_hsupanalog inh_bulkpanalog R='rbulkpanalog'
  R1 inh_hsupcore inh_bulkpcore R='rbulkpcore'
  R0 inh_lSup inh_bulkn R='1m'
.ENDS
** End of subcircuit definition.

** Top cell:
** ---------
** Subcircuit
** ----------
** Library name: phy_local
** Cell name: tb_phy_ana_top_verilog_a
** View name: schematic_02.09.2021
** Inherited view list: veriloga ahdl spectre schematic av_analog_extracted av_extracted netlist
**
XI383<4> bin_s<4> diff_s<4> termination_en_s tx_n<4> tx_p<4> net091<4> VSS! lane_output
XI383<3> bin_s<3> diff_s<3> termination_en_s tx_n<3> tx_p<3> net091<3> VSS! lane_output
XI383<2> bin_s<2> diff_s<2> termination_en_s tx_n<2> tx_p<2> net091<2> VSS! lane_output
XI383<1> bin_s<1> diff_s<1> termination_en_s tx_n<1> tx_p<1> net091<1> VSS! lane_output
XI383<0> bin_s<0> diff_s<0> termination_en_s tx_n<0> tx_p<0> net091<0> VSS! lane_output
VIMess0 net057 net053 DC 0
Vi40u net095 vibias_40u_as DC 0
VIM_vss vss_int VSS! DC 0
VIM_vddd1v5 VDDc! vddd1v5_int DC 0
XI417 vbg VSS! VSSb! VDDba! VDDa! VSS! bandgap
Xana vss_int vss_int vddd1v5_int vddd1v5_int VSS! VSS! cl_bypass_delay_line_i cl_delay_prog_i<2> cl_delay_prog_i<1> cl_delay_prog_i<0> cl_dft_deser_en_i feedback_s<15> feedback_s<14> feedback_s<13> feedback_s<12> feedback_s<11> feedback_s<10> feedback_s<9>
+ feedback_s<8> feedback_s<7> feedback_s<6> feedback_s<5> feedback_s<4> feedback_s<3> feedback_s<2> feedback_s<1> feedback_s<0> cl_dft_hstx_higher_path_en_i cl_dft_hstx_lower_path_en_i cl_dft_ser_test_in_en_i cl_dft_ser_test_n_i cl_dft_ser_test_p_i cl_hs_ser_en_i
+ cl_hstx_data_s<15> cl_hstx_data_s<14> cl_hstx_data_s<13> cl_hstx_data_s<12> cl_hstx_data_s<11> cl_hstx_data_s<10> cl_hstx_data_s<9> cl_hstx_data_s<8> cl_hstx_data_s<7> cl_hstx_data_s<6> cl_hstx_data_s<5> cl_hstx_data_s<4> cl_hstx_data_s<3> cl_hstx_data_s<2>
+ cl_hstx_data_s<1> cl_hstx_data_s<0> cl_hstx_en_lptx_dis_i cl_hstx_pwrdn_i cl_lptx_dn_i cl_lptx_dp_i cl_lptx_en_i tx_byte_clk_o clk_dphy_0_i clk_dphy_90_i clk_dphy_180_i clk_dphy_270_i dft_ana_test_s dft_ana_test_en_i dft_ana_test_out_dphy_sel_i<3>
+ dft_ana_test_out_dphy_sel_i<2> dft_ana_test_out_dphy_sel_i<1> dft_ana_test_out_dphy_sel_i<0> dft_dphy_ocdldo_res_dis_i dft_pll_clks_2_cl_en_i dft_scan_en_i VSS! dl0_bypass_delay_line_i dl0_delay_prog_i<2> dl0_delay_prog_i<1> dl0_delay_prog_i<0>
+ dl0_dft_deser_en_i feedback_s<31> feedback_s<30> feedback_s<29> feedback_s<28> feedback_s<27> feedback_s<26> feedback_s<25> feedback_s<24> feedback_s<23> feedback_s<22> feedback_s<21> feedback_s<20> feedback_s<19> feedback_s<18> feedback_s<17> feedback_s<16>
+ dl0_dft_hstx_higher_path_en_i dl0_dft_hstx_lower_path_en_i dl0_dft_ser_test_in_en_i dl0_dft_ser_test_n_i dl0_dft_ser_test_p_i dl0_hs_ser_en_i dl0_hstx_data_s<15> dl0_hstx_data_s<14> dl0_hstx_data_s<13> dl0_hstx_data_s<12> dl0_hstx_data_s<11> dl0_hstx_data_s<10>
+ dl0_hstx_data_s<9> dl0_hstx_data_s<8> dl0_hstx_data_s<7> dl0_hstx_data_s<6> dl0_hstx_data_s<5> dl0_hstx_data_s<4> dl0_hstx_data_s<3> dl0_hstx_data_s<2> dl0_hstx_data_s<1> dl0_hstx_data_s<0> dl0_hstx_en_lptx_dis_i dl0_hstx_pwrdn_i dl0_lptx_dn_i dl0_lptx_dp_i
+ dl0_lptx_en_i dl1_bypass_delay_line_i dl1_delay_prog_i<2> dl1_delay_prog_i<1> dl1_delay_prog_i<0> dl1_dft_deser_en_i feedback_s<47> feedback_s<46> feedback_s<45> feedback_s<44> feedback_s<43> feedback_s<42> feedback_s<41> feedback_s<40> feedback_s<39>
+ feedback_s<38> feedback_s<37> feedback_s<36> feedback_s<35> feedback_s<34> feedback_s<33> feedback_s<32> dl1_dft_hstx_higher_path_en_i dl1_dft_hstx_lower_path_en_i dl1_dft_ser_test_in_en_i dl1_dft_ser_test_n_i dl1_dft_ser_test_p_i dl1_hs_ser_en_i
+ dl1_hstx_data_s<15> dl1_hstx_data_s<14> dl1_hstx_data_s<13> dl1_hstx_data_s<12> dl1_hstx_data_s<11> dl1_hstx_data_s<10> dl1_hstx_data_s<9> dl1_hstx_data_s<8> dl1_hstx_data_s<7> dl1_hstx_data_s<6> dl1_hstx_data_s<5> dl1_hstx_data_s<4> dl1_hstx_data_s<3>
+ dl1_hstx_data_s<2> dl1_hstx_data_s<1> dl1_hstx_data_s<0> dl1_hstx_en_lptx_dis_i dl1_hstx_pwrdn_i dl1_lptx_dn_i dl1_lptx_dp_i dl1_lptx_en_i dl2_bypass_delay_line_i dl2_delay_prog_i<2> dl2_delay_prog_i<1> dl2_delay_prog_i<0> dl2_dft_deser_en_i feedback_s<63>
+ feedback_s<62> feedback_s<61> feedback_s<60> feedback_s<59> feedback_s<58> feedback_s<57> feedback_s<56> feedback_s<55> feedback_s<54> feedback_s<53> feedback_s<52> feedback_s<51> feedback_s<50> feedback_s<49> feedback_s<48> dl2_dft_hstx_higher_path_en_i
+ dl2_dft_hstx_lower_path_en_i dl2_dft_ser_test_in_en_i dl2_dft_ser_test_n_i dl2_dft_ser_test_p_i dl2_hs_ser_en_i dl2_hstx_data_s<15> dl2_hstx_data_s<14> dl2_hstx_data_s<13> dl2_hstx_data_s<12> dl2_hstx_data_s<11> dl2_hstx_data_s<10> dl2_hstx_data_s<9>
+ dl2_hstx_data_s<8> dl2_hstx_data_s<7> dl2_hstx_data_s<6> dl2_hstx_data_s<5> dl2_hstx_data_s<4> dl2_hstx_data_s<3> dl2_hstx_data_s<2> dl2_hstx_data_s<1> dl2_hstx_data_s<0> dl2_hstx_en_lptx_dis_i dl2_hstx_pwrdn_i dl2_lptx_dn_i dl2_lptx_dp_i dl2_lptx_en_i
+ dl3_bypass_delay_line_i dl3_delay_prog_i<2> dl3_delay_prog_i<1> dl3_delay_prog_i<0> dl3_dft_deser_en_i feedback_s<79> feedback_s<78> feedback_s<77> feedback_s<76> feedback_s<75> feedback_s<74> feedback_s<73> feedback_s<72> feedback_s<71> feedback_s<70>
+ feedback_s<69> feedback_s<68> feedback_s<67> feedback_s<66> feedback_s<65> feedback_s<64> dl3_dft_hstx_higher_path_en_i dl3_dft_hstx_lower_path_en_i dl3_dft_ser_test_in_en_i dl3_dft_ser_test_n_i dl3_dft_ser_test_p_i dl3_hs_ser_en_i dl3_hstx_data_s<15>
+ dl3_hstx_data_s<14> dl3_hstx_data_s<13> dl3_hstx_data_s<12> dl3_hstx_data_s<11> dl3_hstx_data_s<10> dl3_hstx_data_s<9> dl3_hstx_data_s<8> dl3_hstx_data_s<7> dl3_hstx_data_s<6> dl3_hstx_data_s<5> dl3_hstx_data_s<4> dl3_hstx_data_s<3> dl3_hstx_data_s<2>
+ dl3_hstx_data_s<1> dl3_hstx_data_s<0> dl3_hstx_en_lptx_dis_i dl3_hstx_pwrdn_i dl3_lptx_dn_i dl3_lptx_dp_i dl3_lptx_en_i dphy_pwrdn_i dphy_reset_n_i dl1_hs_byte_clk_en_i en_clk_dphy_i en_iso_vddphy_i en_ls_vddphy_i hs_ser_msb_first_en_i hstx_en_fast_trf_i
+ hstx_ldo_vref_ai hstx_lower_imp_cal_i<2> hstx_lower_imp_cal_i<1> hstx_lower_imp_cal_i<0> hstx_upper_imp_cal_i<2> hstx_upper_imp_cal_i<1> hstx_upper_imp_cal_i<0> vibias_40u_as lptx_ldo_vref_ai lptx_vref_prog_i<4> lptx_vref_prog_i<3> lptx_vref_prog_i<2>
+ lptx_vref_prog_i<1> lptx_vref_prog_i<0> VSS! VSS! sel_dr_i tx_n<0> tx_p<0> tx_n<1> tx_p<1> tx_n<2> tx_p<2> tx_n<3> tx_p<3> tx_n<4> tx_p<4> VSSb! VDDbc! phy_ana_top
XI407<4> net0100<4> loopback_prbs_checker_err_s<4> tx_byte_clk_o feedback_s<79> feedback_s<78> feedback_s<77> feedback_s<76> feedback_s<75> feedback_s<74> feedback_s<73> feedback_s<72> feedback_s<71> feedback_s<70> feedback_s<69> feedback_s<68> feedback_s<67>
+ feedback_s<66> feedback_s<65> feedback_s<64> loopback_prbs_checker_en_s<4> va_prbs_checker vhigh='1.5' trf='3e-11' skipFirstXClks='6'
XI407<3> net0100<3> loopback_prbs_checker_err_s<3> tx_byte_clk_o feedback_s<63> feedback_s<62> feedback_s<61> feedback_s<60> feedback_s<59> feedback_s<58> feedback_s<57> feedback_s<56> feedback_s<55> feedback_s<54> feedback_s<53> feedback_s<52> feedback_s<51>
+ feedback_s<50> feedback_s<49> feedback_s<48> loopback_prbs_checker_en_s<3> va_prbs_checker vhigh='1.5' trf='3e-11' skipFirstXClks='6'
XI407<2> net0100<2> loopback_prbs_checker_err_s<2> tx_byte_clk_o feedback_s<47> feedback_s<46> feedback_s<45> feedback_s<44> feedback_s<43> feedback_s<42> feedback_s<41> feedback_s<40> feedback_s<39> feedback_s<38> feedback_s<37> feedback_s<36> feedback_s<35>
+ feedback_s<34> feedback_s<33> feedback_s<32> loopback_prbs_checker_en_s<2> va_prbs_checker vhigh='1.5' trf='3e-11' skipFirstXClks='6'
XI407<1> net0100<1> loopback_prbs_checker_err_s<1> tx_byte_clk_o feedback_s<31> feedback_s<30> feedback_s<29> feedback_s<28> feedback_s<27> feedback_s<26> feedback_s<25> feedback_s<24> feedback_s<23> feedback_s<22> feedback_s<21> feedback_s<20> feedback_s<19>
+ feedback_s<18> feedback_s<17> feedback_s<16> loopback_prbs_checker_en_s<1> va_prbs_checker vhigh='1.5' trf='3e-11' skipFirstXClks='6'
XI407<0> net0100<0> loopback_prbs_checker_err_s<0> tx_byte_clk_o feedback_s<15> feedback_s<14> feedback_s<13> feedback_s<12> feedback_s<11> feedback_s<10> feedback_s<9> feedback_s<8> feedback_s<7> feedback_s<6> feedback_s<5> feedback_s<4> feedback_s<3>
+ feedback_s<2> feedback_s<1> feedback_s<0> loopback_prbs_checker_en_s<0> va_prbs_checker vhigh='1.5' trf='3e-11' skipFirstXClks='6'
XI406<4> output_prbs_checker_counter_ai<4> output_prbs_checker_error_s<4> tx_byte_clk_o data_s<63> data_s<62> data_s<61> data_s<60> data_s<59> data_s<58> data_s<57> data_s<56> data_s<55> data_s<54> data_s<53> data_s<52> data_s<51> data_s<50> data_s<49> data_s<48>
+ deser_en_s va_prbs_checker vhigh='1.5' trf='3e-11' skipFirstXClks='6'
XI406<3> output_prbs_checker_counter_ai<3> output_prbs_checker_error_s<3> tx_byte_clk_o data_s<47> data_s<46> data_s<45> data_s<44> data_s<43> data_s<42> data_s<41> data_s<40> data_s<39> data_s<38> data_s<37> data_s<36> data_s<35> data_s<34> data_s<33> data_s<32>
+ deser_en_s va_prbs_checker vhigh='1.5' trf='3e-11' skipFirstXClks='6'
XI406<2> output_prbs_checker_counter_ai<2> output_prbs_checker_error_s<2> tx_byte_clk_o data_s<31> data_s<30> data_s<29> data_s<28> data_s<27> data_s<26> data_s<25> data_s<24> data_s<23> data_s<22> data_s<21> data_s<20> data_s<19> data_s<18> data_s<17> data_s<16>
+ deser_en_s va_prbs_checker vhigh='1.5' trf='3e-11' skipFirstXClks='6'
XI406<1> output_prbs_checker_counter_ai<1> output_prbs_checker_error_s<1> tx_byte_clk_o data_s<15> data_s<14> data_s<13> data_s<12> data_s<11> data_s<10> data_s<9> data_s<8> data_s<7> data_s<6> data_s<5> data_s<4> data_s<3> data_s<2> data_s<1> data_s<0>
+ deser_en_s va_prbs_checker vhigh='1.5' trf='3e-11' skipFirstXClks='6'
XI416 VSS! net057 net095 hstx_ldo_vref_ai lptx_ldo_vref_ai vbg VSSb! VDDba! VDDa! VSS! cell_bg_precond
XI393 clk_okay_s output_prbs_checker_counter_ai<4> output_prbs_checker_counter_ai<3> output_prbs_checker_counter_ai<2> output_prbs_checker_counter_ai<1> loopback_prbs_checker_en_s<4> loopback_prbs_checker_en_s<3> loopback_prbs_checker_en_s<2>
+ loopback_prbs_checker_en_s<1> loopback_prbs_checker_en_s<0> loopback_prbs_checker_err_s<4> loopback_prbs_checker_err_s<3> loopback_prbs_checker_err_s<2> loopback_prbs_checker_err_s<1> loopback_prbs_checker_err_s<0> output_prbs_checker_error_s<4>
+ output_prbs_checker_error_s<3> output_prbs_checker_error_s<2> output_prbs_checker_error_s<1> waveform_analyzer_ideal_min_max_s deser_en_s fail_s termination_en_s reset_stimuli_s delay_s<4> delay_s<3> delay_s<2> delay_s<1> delay_s<0> dft_ana_test_en_i
+ dft_ana_test_out_dphy_sel_i<3> dft_ana_test_out_dphy_sel_i<2> dft_ana_test_out_dphy_sel_i<1> dft_ana_test_out_dphy_sel_i<0> dft_dphy_ocdldo_res_dis_i dft_pll_clks_2_cl_en_i dft_scan_en_i dphy_pwrdn_i dphy_reset_n_i en_1GHz_quad_s net0132 dl1_hs_byte_clk_en_i
+ en_clk_dphy_i en_iso_vddphy_i en_ls_vddphy_i hs_ser_msb_first_en_i hstx_en_fast_trf_i hstx_lower_imp_cal_i<2> hstx_lower_imp_cal_i<1> hstx_lower_imp_cal_i<0> hstx_upper_imp_cal_i<2> hstx_upper_imp_cal_i<1> hstx_upper_imp_cal_i<0> lptx_vref_prog_i<4>
+ lptx_vref_prog_i<3> lptx_vref_prog_i<2> lptx_vref_prog_i<1> lptx_vref_prog_i<0> mode_s<4> mode_s<3> mode_s<2> mode_s<1> mode_s<0> lock_s sel_dr_i test_id bin_s<4> bin_s<3> bin_s<2> bin_s<1> bin_s<0> tx_byte_clk_o diff_s<4> diff_s<3> diff_s<2> diff_s<1>
+ diff_s<0> net093 tx_n<4> tx_n<3> tx_n<2> tx_n<1> tx_n<0> tx_p<4> tx_p<3> tx_p<2> tx_p<1> tx_p<0> waveform_analyzer_en_s xopen0_s<3> xopen0_s<2> xopen0_s<1> xopen0_s<0> xopen1_s<3> xopen1_s<2> xopen1_s<1> xopen1_s<0> yopen0_s<3> yopen0_s<2> yopen0_s<1>
+ yopen0_s<0> yopen1_s<3> yopen1_s<2> yopen1_s<1> yopen1_s<0> rise_s<3> rise_s<2> rise_s<1> rise_s<0> fall_s<3> fall_s<2> fall_s<1> fall_s<0> max_s<3> max_s<2> max_s<1> max_s<0> min_s<3> min_s<2> min_s<1> min_s<0> UI_s<3> UI_s<2> UI_s<1> UI_s<0> ready_s<3>
+ ready_s<2> ready_s<1> ready_s<0> dft_ana_test_s va_common_stimuli vhigh='1.5' trf='3e-11' stop_on_error='1' rampup_num_ok='5' rampup_max_dv='0.0002' rampup_trigger_v='0.35' rampup_max_time='3e-05' ldo_settling_time='3e-08' ldo_dv='0.01' lptx_freq='2.5e+07'
+ lptx_rise_fall_max_ns='29.1667' lptx_h_min='0.95' lptx_h_max='1.3' dc_test_current='0.002' dc_allowed_v_tol='0.05' dc_lptx_allowed_v_tol='0.15' dc_settling_time='5e-08' dc_hstx_expected_high='0.4' dc_lptx_expected_high='1.2' dc_lptx_R_min='110'
+ dc_hstx_max_cmtx_mismatch='0.005' dc_hstx_max_od_mismatch='0.014' delay_line_measure_time='1.5e-07' delay_line_acceptable_dt_rel='0.2' pll_max_lock_time='5e-06' pll_wait_time='pll_wait_time' delay_ready_timeout='5e-07' T_EYE_TX_LOWER_LIMIT='0.5'
+ V_DIF_TX_LOWER_LIMIT='0.04' TRF_MAX='0.35' TRF_MIN='0.1'
XI394 clk_okay_s clk_dphy_0_i clk_dphy_90_i clk_dphy_180_i clk_dphy_270_i lock_s en_1GHz_quad_s net053 VSS! cell_dll_wrapper
XI408 VSSb! VDDba! VDDbc! VDDa! VDDc! VSS! supplies
V13 net093 VSS! DC='0' PWL( '0' '0' '1n' '0' '2n' '1.5') TD='10n'
XI1<3> waveform_analyzer_ideal_min_max_s UI_s<3> fall_s<3> max_s<3> min_s<3> ready_s<3> xopen0_s<3> xopen1_s<3> yopen0_s<3> yopen1_s<3> diff_s<0> diff_s<4> waveform_analyzer_en_s rise_s<3> lane_waveform_analyzer vhigh='1.5' trf='3e-11' trf_rel_threashold='0.2'
XI1<2> waveform_analyzer_ideal_min_max_s UI_s<2> fall_s<2> max_s<2> min_s<2> ready_s<2> xopen0_s<2> xopen1_s<2> yopen0_s<2> yopen1_s<2> diff_s<0> diff_s<3> waveform_analyzer_en_s rise_s<2> lane_waveform_analyzer vhigh='1.5' trf='3e-11' trf_rel_threashold='0.2'
XI1<1> waveform_analyzer_ideal_min_max_s UI_s<1> fall_s<1> max_s<1> min_s<1> ready_s<1> xopen0_s<1> xopen1_s<1> yopen0_s<1> yopen1_s<1> diff_s<0> diff_s<2> waveform_analyzer_en_s rise_s<1> lane_waveform_analyzer vhigh='1.5' trf='3e-11' trf_rel_threashold='0.2'
XI1<0> waveform_analyzer_ideal_min_max_s UI_s<0> fall_s<0> max_s<0> min_s<0> ready_s<0> xopen0_s<0> xopen1_s<0> yopen0_s<0> yopen1_s<0> diff_s<0> diff_s<1> waveform_analyzer_en_s rise_s<0> lane_waveform_analyzer vhigh='1.5' trf='3e-11' trf_rel_threashold='0.2'
Xdeser<4> data_s<63> data_s<62> data_s<61> data_s<60> data_s<59> data_s<58> data_s<57> data_s<56> data_s<55> data_s<54> data_s<53> data_s<52> data_s<51> data_s<50> data_s<49> data_s<48> bin_s<0> bin_s<4> deser_en_s va_deserializer
Xdeser<3> data_s<47> data_s<46> data_s<45> data_s<44> data_s<43> data_s<42> data_s<41> data_s<40> data_s<39> data_s<38> data_s<37> data_s<36> data_s<35> data_s<34> data_s<33> data_s<32> bin_s<0> bin_s<3> deser_en_s va_deserializer
Xdeser<2> data_s<31> data_s<30> data_s<29> data_s<28> data_s<27> data_s<26> data_s<25> data_s<24> data_s<23> data_s<22> data_s<21> data_s<20> data_s<19> data_s<18> data_s<17> data_s<16> bin_s<0> bin_s<2> deser_en_s va_deserializer
Xdeser<1> data_s<15> data_s<14> data_s<13> data_s<12> data_s<11> data_s<10> data_s<9> data_s<8> data_s<7> data_s<6> data_s<5> data_s<4> data_s<3> data_s<2> data_s<1> data_s<0> bin_s<0> bin_s<1> deser_en_s va_deserializer
XI388 dl0_bypass_delay_line_i dl0_delay_prog_i<2> dl0_delay_prog_i<1> dl0_delay_prog_i<0> dl0_dft_deser_en_i reset_stimuli_s dl0_dft_hstx_higher_path_en_i dl0_dft_hstx_lower_path_en_i dl0_dft_ser_test_in_en_i dl0_dft_ser_test_n_i dl0_dft_ser_test_p_i
+ dl0_hs_ser_en_i dl0_hstx_data_s<15> dl0_hstx_data_s<14> dl0_hstx_data_s<13> dl0_hstx_data_s<12> dl0_hstx_data_s<11> dl0_hstx_data_s<10> dl0_hstx_data_s<9> dl0_hstx_data_s<8> dl0_hstx_data_s<7> dl0_hstx_data_s<6> dl0_hstx_data_s<5> dl0_hstx_data_s<4>
+ dl0_hstx_data_s<3> dl0_hstx_data_s<2> dl0_hstx_data_s<1> dl0_hstx_data_s<0> dl0_hstx_en_lptx_dis_i dl0_hstx_pwrdn_i dl0_lptx_dn_i dl0_lptx_dp_i dl0_lptx_en_i tx_byte_clk_o delay_s<1> mode_s<1> va_lane_stimuli vhigh='1.5' trf='1e-09' prbs_offset='0'
XI392 dl3_bypass_delay_line_i dl3_delay_prog_i<2> dl3_delay_prog_i<1> dl3_delay_prog_i<0> dl3_dft_deser_en_i reset_stimuli_s dl3_dft_hstx_higher_path_en_i dl3_dft_hstx_lower_path_en_i dl3_dft_ser_test_in_en_i dl3_dft_ser_test_n_i dl3_dft_ser_test_p_i
+ dl3_hs_ser_en_i dl3_hstx_data_s<15> dl3_hstx_data_s<14> dl3_hstx_data_s<13> dl3_hstx_data_s<12> dl3_hstx_data_s<11> dl3_hstx_data_s<10> dl3_hstx_data_s<9> dl3_hstx_data_s<8> dl3_hstx_data_s<7> dl3_hstx_data_s<6> dl3_hstx_data_s<5> dl3_hstx_data_s<4>
+ dl3_hstx_data_s<3> dl3_hstx_data_s<2> dl3_hstx_data_s<1> dl3_hstx_data_s<0> dl3_hstx_en_lptx_dis_i dl3_hstx_pwrdn_i dl3_lptx_dn_i dl3_lptx_dp_i dl3_lptx_en_i tx_byte_clk_o delay_s<4> mode_s<4> va_lane_stimuli vhigh='1.5' trf='1e-09' prbs_offset='4'
XI391 dl2_bypass_delay_line_i dl2_delay_prog_i<2> dl2_delay_prog_i<1> dl2_delay_prog_i<0> dl2_dft_deser_en_i reset_stimuli_s dl2_dft_hstx_higher_path_en_i dl2_dft_hstx_lower_path_en_i dl2_dft_ser_test_in_en_i dl2_dft_ser_test_n_i dl2_dft_ser_test_p_i
+ dl2_hs_ser_en_i dl2_hstx_data_s<15> dl2_hstx_data_s<14> dl2_hstx_data_s<13> dl2_hstx_data_s<12> dl2_hstx_data_s<11> dl2_hstx_data_s<10> dl2_hstx_data_s<9> dl2_hstx_data_s<8> dl2_hstx_data_s<7> dl2_hstx_data_s<6> dl2_hstx_data_s<5> dl2_hstx_data_s<4>
+ dl2_hstx_data_s<3> dl2_hstx_data_s<2> dl2_hstx_data_s<1> dl2_hstx_data_s<0> dl2_hstx_en_lptx_dis_i dl2_hstx_pwrdn_i dl2_lptx_dn_i dl2_lptx_dp_i dl2_lptx_en_i tx_byte_clk_o delay_s<3> mode_s<3> va_lane_stimuli vhigh='1.5' trf='1e-09' prbs_offset='3'
XI389 dl1_bypass_delay_line_i dl1_delay_prog_i<2> dl1_delay_prog_i<1> dl1_delay_prog_i<0> dl1_dft_deser_en_i reset_stimuli_s dl1_dft_hstx_higher_path_en_i dl1_dft_hstx_lower_path_en_i dl1_dft_ser_test_in_en_i dl1_dft_ser_test_n_i dl1_dft_ser_test_p_i
+ dl1_hs_ser_en_i dl1_hstx_data_s<15> dl1_hstx_data_s<14> dl1_hstx_data_s<13> dl1_hstx_data_s<12> dl1_hstx_data_s<11> dl1_hstx_data_s<10> dl1_hstx_data_s<9> dl1_hstx_data_s<8> dl1_hstx_data_s<7> dl1_hstx_data_s<6> dl1_hstx_data_s<5> dl1_hstx_data_s<4>
+ dl1_hstx_data_s<3> dl1_hstx_data_s<2> dl1_hstx_data_s<1> dl1_hstx_data_s<0> dl1_hstx_en_lptx_dis_i dl1_hstx_pwrdn_i dl1_lptx_dn_i dl1_lptx_dp_i dl1_lptx_en_i tx_byte_clk_o delay_s<2> mode_s<2> va_lane_stimuli vhigh='1.5' trf='1e-09' prbs_offset='1'
XI390 cl_bypass_delay_line_i cl_delay_prog_i<2> cl_delay_prog_i<1> cl_delay_prog_i<0> cl_dft_deser_en_i reset_stimuli_s cl_dft_hstx_higher_path_en_i cl_dft_hstx_lower_path_en_i cl_dft_ser_test_in_en_i cl_dft_ser_test_n_i cl_dft_ser_test_p_i cl_hs_ser_en_i
+ cl_hstx_data_s<15> cl_hstx_data_s<14> cl_hstx_data_s<13> cl_hstx_data_s<12> cl_hstx_data_s<11> cl_hstx_data_s<10> cl_hstx_data_s<9> cl_hstx_data_s<8> cl_hstx_data_s<7> cl_hstx_data_s<6> cl_hstx_data_s<5> cl_hstx_data_s<4> cl_hstx_data_s<3> cl_hstx_data_s<2>
+ cl_hstx_data_s<1> cl_hstx_data_s<0> cl_hstx_en_lptx_dis_i cl_hstx_pwrdn_i cl_lptx_dn_i cl_lptx_dp_i cl_lptx_en_i tx_byte_clk_o delay_s<0> mode_s<0> va_lane_stimuli vhigh='1.5' trf='1e-09' prbs_offset='2'
** End of top cell tb_phy_ana_top_verilog_a.

.hdl "checker/veriloga/va_comparator/veriloga/veriloga.va"
.hdl "checker/veriloga/va_prbs_checker/veriloga/veriloga.va"
.hdl "checker/veriloga/va_common_stimuli/veriloga/veriloga.va"
.hdl "checker/veriloga/va_pll_model/veriloga/veriloga.va"
.hdl "checker/veriloga/va_lane_waveform_analyzer/veriloga/veriloga.va"
.hdl "checker/veriloga/va_deserializer/veriloga/veriloga.va"
.hdl "checker/veriloga/va_lane_stimuli/veriloga/veriloga.va"
